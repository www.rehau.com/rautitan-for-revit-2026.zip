Properties of the parts of a building model (IFC4), part 8 of 10

# IfcPipeFitting: Sleeve:LX 7,4 (48)
Name (Sleeve:LX 7,4:...) | DN1 (mm) | L1 (mm) | Description long | GTIN | Product Group | Product URL | Weight
1440944 | 10 | 15 | REHAU compression sleeve SDR 11/7,4 LX 12 x 1,1 / 12 x 1,7 / 12 x 2,0 | 4007360057114 | 1957 | https://oxomi.com/p/3000126/datasheet/-/11386131001 | 0.01
1441232 | 10 | 15 | REHAU compression sleeve SDR 11/7,4 LX 12 x 1,1 / 12 x 1,7 / 12 x 2,0 | 4007360057114 | 1957 | https://oxomi.com/p/3000126/datasheet/-/11386131001 | 0.01
1441234 | 10 | 15 | REHAU compression sleeve SDR 11/7,4 LX 12 x 1,1 / 12 x 1,7 / 12 x 2,0 | 4007360057114 | 1957 | https://oxomi.com/p/3000126/datasheet/-/11386131001 | 0.01
1451460 | 10 | 15 | REHAU compression sleeve SDR 11/7,4 LX 12 x 1,1 / 12 x 1,7 / 12 x 2,0 | 4007360057114 | 1957 | https://oxomi.com/p/3000126/datasheet/-/11386131001 | 0.01
1454193 | 12 | 24 | REHAU Compression sleeve RAUT. MX/LX 16 | 4007360031053 | 1958 | https://oxomi.com/p/3000126/datasheet/-/12596051002 | 0.025
1454195 | 10 | 15 | REHAU compression sleeve SDR 11/7,4 LX 12 x 1,1 / 12 x 1,7 / 12 x 2,0 | 4007360057114 | 1957 | https://oxomi.com/p/3000126/datasheet/-/11386131001 | 0.01

# IfcPipeFitting: Sleeve:PX 7,4 (450)
In: REHAU Starting view
Type - Material: PX
Type - Other - Category: Pipe Fittings; Family Name: Sleeve
Type - Constraints - Default Elevation: 0 mm
Type - Identity Data - Cost: 0; Description: PX 7,4; Manufacturer: REHAU; Model: PX 7,4; REHAU Info: 14.02.2024-420668-420668; Type Name: PX 7,4
Type - Materials and Finishes - Mat. Sleeve: PX
Type - Pset_ManufacturerTypeInformation - Manufacturer: REHAU
Pset_EnvironmentalImpactIndicators - Reference: Sleeve:PX 7,4; sets with these values: 2
Other - IsCustom: no; Family: Sleeve; Family and Type: Sleeve: PX 7,4; T1: Sleeve DN; Type: PX 7,4; Type Id: 986515
Constraints - Elevation from Level: 0 mm; Level: REHAU Starting view; Moves With Nearby Elements: no
Data - Language: Description en; PID Check: 1 mm; Region Check: Check DE; Region PID: PID DE
Dimensions - Area: 0.00262625 m2
Identity Data - Sorting: 0; ETIM Class: EC011668; ETIM Group: EG015540; ETIM Name: Accessories/spare parts for fittings; Tender text: -
Phasing - Phase Created: New Construction
Insulation - Insulation Thickness: 0 mm
Name (Sleeve:PX 7,4:...) | Language Tender Text | Region URL | DN1 (mm) | L1 (mm) | Volume (m3) | Description long | GTIN | PID | Product Group | Product URL | Weight
986656 | Tender Text en | Product URL DE | 12 | 23.7 | 0.00000312848 | REHAU Compression sleeve RAUTITAN PX 16 | 4007360361204 | 11600011001 | 1947 | https://oxomi.com/p/3000126/datasheet/-/11600011001 | 0.0076
986658 | Tender Text en | Product URL DE | 12 | 23.7 | 0.00000312848 | REHAU Compression sleeve RAUTITAN PX 16 | 4007360361204 | 11600011001 | 1947 | https://oxomi.com/p/3000126/datasheet/-/11600011001 | 0.0076
986662 | Tender Text en | Product URL DE | 15 | 25 | 0.00000516767 | REHAU Compression sleeve RAUTITAN PX 20 | 4007360361211 | 11600021001 | 1949 | https://oxomi.com/p/3000126/datasheet/-/11600021001 | 0.011
986664 | Tender Text en | Product URL DE | 15 | 25 | 0.00000516767 | REHAU Compression sleeve RAUTITAN PX 20 | 4007360361211 | 11600021001 | 1949 | https://oxomi.com/p/3000126/datasheet/-/11600021001 | 0.011
986669 | Tender Text en | Product URL DE | 20 | 27.2 | 0.0000087028 | REHAU Compression sleeve RAUTITAN PX 25 | 4007360361228 | 11600031001 | 1950 | https://oxomi.com/p/3000126/datasheet/-/11600031001 | 0.015828
986671 | Tender Text en | Product URL DE | 20 | 27.2 | 0.0000087028 | REHAU Compression sleeve RAUTITAN PX 25 | 4007360361228 | 11600031001 | 1950 | https://oxomi.com/p/3000126/datasheet/-/11600031001 | 0.015828
986676 | Tender Text en | Product URL DE | 25 | 34 | 0.0000174355 | REHAU Compression sleeve RAUTITAN PX 32 | 4007360361235 | 11600041001 | 1951 | https://oxomi.com/p/3000126/datasheet/-/11600041001 | 0.027828
986678 | Tender Text en | Product URL DE | 25 | 34 | 0.0000174355 | REHAU Compression sleeve RAUTITAN PX 32 | 4007360361235 | 11600041001 | 1951 | https://oxomi.com/p/3000126/datasheet/-/11600041001 | 0.027828
986682 | Tender Text en | Product URL DE | 32 | 37.8 | 0.0000303041 | REHAU Compression sleeve RAUTITAN PX 40 | 4007360361242 | 11600051001 | 1952 | https://oxomi.com/p/3000126/datasheet/-/11600051001 | 0.03861
986684 | Tender Text en | Product URL DE | 32 | 37.8 | 0.0000303041 | REHAU Compression sleeve RAUTITAN PX 40 | 4007360361242 | 11600051001 | 1952 | https://oxomi.com/p/3000126/datasheet/-/11600051001 | 0.03861
1007424 | Tender Text en | Product URL DE | 12 | 23.7 | 0.00000312848 | REHAU Compression sleeve RAUTITAN PX 16 | 4007360361204 | 11600011001 | 1947 | https://oxomi.com/p/3000126/datasheet/-/11600011001 | 0.0076
1007426 | Tender Text en | Product URL DE | 12 | 23.7 | 0.00000312848 | REHAU Compression sleeve RAUTITAN PX 16 | 4007360361204 | 11600011001 | 1947 | https://oxomi.com/p/3000126/datasheet/-/11600011001 | 0.0076
1007428 | Tender Text en | Product URL DE | 12 | 23.7 | 0.00000312848 | REHAU Compression sleeve RAUTITAN PX 16 | 4007360361204 | 11600011001 | 1947 | https://oxomi.com/p/3000126/datasheet/-/11600011001 | 0.0076
1007430 | Tender Text en | Product URL DE | 20 | 27.2 | 0.0000087028 | REHAU Compression sleeve RAUTITAN PX 25 | 4007360361228 | 11600031001 | 1950 | https://oxomi.com/p/3000126/datasheet/-/11600031001 | 0.015828
1007432 | Tender Text en | Product URL DE | 20 | 27.2 | 0.0000087028 | REHAU Compression sleeve RAUTITAN PX 25 | 4007360361228 | 11600031001 | 1950 | https://oxomi.com/p/3000126/datasheet/-/11600031001 | 0.015828
1007434 | Tender Text en | Product URL DE | 20 | 27.2 | 0.0000087028 | REHAU Compression sleeve RAUTITAN PX 25 | 4007360361228 | 11600031001 | 1950 | https://oxomi.com/p/3000126/datasheet/-/11600031001 | 0.015828
1007436 | Tender Text en | Product URL DE | 25 | 34 | 0.0000174355 | REHAU Compression sleeve RAUTITAN PX 32 | 4007360361235 | 11600041001 | 1951 | https://oxomi.com/p/3000126/datasheet/-/11600041001 | 0.027828
1007438 | Tender Text en | Product URL DE | 25 | 34 | 0.0000174355 | REHAU Compression sleeve RAUTITAN PX 32 | 4007360361235 | 11600041001 | 1951 | https://oxomi.com/p/3000126/datasheet/-/11600041001 | 0.027828
1007440 | Tender Text en | Product URL DE | 25 | 34 | 0.0000174355 | REHAU Compression sleeve RAUTITAN PX 32 | 4007360361235 | 11600041001 | 1951 | https://oxomi.com/p/3000126/datasheet/-/11600041001 | 0.027828
1007442 | Tender Text en | Product URL DE | 32 | 37.8 | 0.0000303041 | REHAU Compression sleeve RAUTITAN PX 40 | 4007360361242 | 11600051001 | 1952 | https://oxomi.com/p/3000126/datasheet/-/11600051001 | 0.03861
1007444 | Tender Text en | Product URL DE | 32 | 37.8 | 0.0000303041 | REHAU Compression sleeve RAUTITAN PX 40 | 4007360361242 | 11600051001 | 1952 | https://oxomi.com/p/3000126/datasheet/-/11600051001 | 0.03861
1007446 | Tender Text en | Product URL DE | 32 | 37.8 | 0.0000303041 | REHAU Compression sleeve RAUTITAN PX 40 | 4007360361242 | 11600051001 | 1952 | https://oxomi.com/p/3000126/datasheet/-/11600051001 | 0.03861
1007460 | Tender Text en | Product URL DE | 15 | 25 | 0.00000516767 | REHAU Compression sleeve RAUTITAN PX 20 | 4007360361211 | 11600021001 | 1949 | https://oxomi.com/p/3000126/datasheet/-/11600021001 | 0.011
1007462 | Tender Text en | Product URL DE | 15 | 25 | 0.00000516767 | REHAU Compression sleeve RAUTITAN PX 20 | 4007360361211 | 11600021001 | 1949 | https://oxomi.com/p/3000126/datasheet/-/11600021001 | 0.011
1007464 | Tender Text en | Product URL DE | 15 | 25 | 0.00000516767 | REHAU Compression sleeve RAUTITAN PX 20 | 4007360361211 | 11600021001 | 1949 | https://oxomi.com/p/3000126/datasheet/-/11600021001 | 0.011
1007466 | Tender Text en | Product URL DE | 12 | 23.7 | 0.00000312848 | REHAU Compression sleeve RAUTITAN PX 16 | 4007360361204 | 11600011001 | 1947 | https://oxomi.com/p/3000126/datasheet/-/11600011001 | 0.0076
1007470 | Tender Text en | Product URL DE | 12 | 23.7 | 0.00000312848 | REHAU Compression sleeve RAUTITAN PX 16 | 4007360361204 | 11600011001 | 1947 | https://oxomi.com/p/3000126/datasheet/-/11600011001 | 0.0076
1007472 | Tender Text en | Product URL DE | 20 | 27.2 | 0.0000087028 | REHAU Compression sleeve RAUTITAN PX 25 | 4007360361228 | 11600031001 | 1950 | https://oxomi.com/p/3000126/datasheet/-/11600031001 | 0.015828
1007474 | Tender Text en | Product URL DE | 15 | 25 | 0.00000516767 | REHAU Compression sleeve RAUTITAN PX 20 | 4007360361211 | 11600021001 | 1949 | https://oxomi.com/p/3000126/datasheet/-/11600021001 | 0.011
1007476 | Tender Text en | Product URL DE | 20 | 27.2 | 0.0000087028 | REHAU Compression sleeve RAUTITAN PX 25 | 4007360361228 | 11600031001 | 1950 | https://oxomi.com/p/3000126/datasheet/-/11600031001 | 0.015828
1007478 | Tender Text en | Product URL DE | 25 | 34 | 0.0000174355 | REHAU Compression sleeve RAUTITAN PX 32 | 4007360361235 | 11600041001 | 1951 | https://oxomi.com/p/3000126/datasheet/-/11600041001 | 0.027828
1007480 | Tender Text en | Product URL DE | 20 | 27.2 | 0.0000087028 | REHAU Compression sleeve RAUTITAN PX 25 | 4007360361228 | 11600031001 | 1950 | https://oxomi.com/p/3000126/datasheet/-/11600031001 | 0.015828
1007482 | Tender Text en | Product URL DE | 25 | 34 | 0.0000174355 | REHAU Compression sleeve RAUTITAN PX 32 | 4007360361235 | 11600041001 | 1951 | https://oxomi.com/p/3000126/datasheet/-/11600041001 | 0.027828
1007484 | Tender Text en | Product URL DE | 32 | 37.8 | 0.0000303041 | REHAU Compression sleeve RAUTITAN PX 40 | 4007360361242 | 11600051001 | 1952 | https://oxomi.com/p/3000126/datasheet/-/11600051001 | 0.03861
1007486 | Tender Text en | Product URL DE | 25 | 34 | 0.0000174355 | REHAU Compression sleeve RAUTITAN PX 32 | 4007360361235 | 11600041001 | 1951 | https://oxomi.com/p/3000126/datasheet/-/11600041001 | 0.027828
1007488 | Tender Text en | Product URL DE | 32 | 37.8 | 0.0000303041 | REHAU Compression sleeve RAUTITAN PX 40 | 4007360361242 | 11600051001 | 1952 | https://oxomi.com/p/3000126/datasheet/-/11600051001 | 0.03861
1007492 | Tender Text en | Product URL DE | 32 | 37.8 | 0.0000303041 | REHAU Compression sleeve RAUTITAN PX 40 | 4007360361242 | 11600051001 | 1952 | https://oxomi.com/p/3000126/datasheet/-/11600051001 | 0.03861
1007502 | Tender Text en | Product URL DE | 15 | 25 | 0.00000516767 | REHAU Compression sleeve RAUTITAN PX 20 | 4007360361211 | 11600021001 | 1949 | https://oxomi.com/p/3000126/datasheet/-/11600021001 | 0.011
1007504 | Tender Text en | Product URL DE | 12 | 23.7 | 0.00000312848 | REHAU Compression sleeve RAUTITAN PX 16 | 4007360361204 | 11600011001 | 1947 | https://oxomi.com/p/3000126/datasheet/-/11600011001 | 0.0076
1007506 | Tender Text en | Product URL DE | 15 | 25 | 0.00000516767 | REHAU Compression sleeve RAUTITAN PX 20 | 4007360361211 | 11600021001 | 1949 | https://oxomi.com/p/3000126/datasheet/-/11600021001 | 0.011
1007508 | Tender Text en | Product URL DE | 20 | 27.2 | 0.0000087028 | REHAU Compression sleeve RAUTITAN PX 25 | 4007360361228 | 11600031001 | 1950 | https://oxomi.com/p/3000126/datasheet/-/11600031001 | 0.015828
1007510 | Tender Text en | Product URL DE | 12 | 23.7 | 0.00000312848 | REHAU Compression sleeve RAUTITAN PX 16 | 4007360361204 | 11600011001 | 1947 | https://oxomi.com/p/3000126/datasheet/-/11600011001 | 0.0076
1007512 | Tender Text en | Product URL DE | 20 | 27.2 | 0.0000087028 | REHAU Compression sleeve RAUTITAN PX 25 | 4007360361228 | 11600031001 | 1950 | https://oxomi.com/p/3000126/datasheet/-/11600031001 | 0.015828
1007514 | Tender Text en | Product URL DE | 25 | 34 | 0.0000174355 | REHAU Compression sleeve RAUTITAN PX 32 | 4007360361235 | 11600041001 | 1951 | https://oxomi.com/p/3000126/datasheet/-/11600041001 | 0.027828
1007516 | Tender Text en | Product URL DE | 15 | 25 | 0.00000516767 | REHAU Compression sleeve RAUTITAN PX 20 | 4007360361211 | 11600021001 | 1949 | https://oxomi.com/p/3000126/datasheet/-/11600021001 | 0.011
1007518 | Tender Text en | Product URL DE | 25 | 34 | 0.0000174355 | REHAU Compression sleeve RAUTITAN PX 32 | 4007360361235 | 11600041001 | 1951 | https://oxomi.com/p/3000126/datasheet/-/11600041001 | 0.027828
1007520 | Tender Text en | Product URL DE | 32 | 37.8 | 0.0000303041 | REHAU Compression sleeve RAUTITAN PX 40 | 4007360361242 | 11600051001 | 1952 | https://oxomi.com/p/3000126/datasheet/-/11600051001 | 0.03861
1007522 | Tender Text en | Product URL DE | 20 | 27.2 | 0.0000087028 | REHAU Compression sleeve RAUTITAN PX 25 | 4007360361228 | 11600031001 | 1950 | https://oxomi.com/p/3000126/datasheet/-/11600031001 | 0.015828
1007524 | Tender Text en | Product URL DE | 32 | 37.8 | 0.0000303041 | REHAU Compression sleeve RAUTITAN PX 40 | 4007360361242 | 11600051001 | 1952 | https://oxomi.com/p/3000126/datasheet/-/11600051001 | 0.03861
1007528 | Tender Text en | Product URL DE | 25 | 34 | 0.0000174355 | REHAU Compression sleeve RAUTITAN PX 32 | 4007360361235 | 11600041001 | 1951 | https://oxomi.com/p/3000126/datasheet/-/11600041001 | 0.027828
1007534 | Tender Text en | Product URL DE | 25 | 34 | 0.0000174355 | REHAU Compression sleeve RAUTITAN PX 32 | 4007360361235 | 11600041001 | 1951 | https://oxomi.com/p/3000126/datasheet/-/11600041001 | 0.027828
1007538 | Tender Text en | Product URL DE | 15 | 25 | 0.00000516767 | REHAU Compression sleeve RAUTITAN PX 20 | 4007360361211 | 11600021001 | 1949 | https://oxomi.com/p/3000126/datasheet/-/11600021001 | 0.011
1007542 | Tender Text en | Product URL DE | 15 | 25 | 0.00000516767 | REHAU Compression sleeve RAUTITAN PX 20 | 4007360361211 | 11600021001 | 1949 | https://oxomi.com/p/3000126/datasheet/-/11600021001 | 0.011
1007546 | Tender Text en | Product URL DE | 20 | 27.2 | 0.0000087028 | REHAU Compression sleeve RAUTITAN PX 25 | 4007360361228 | 11600031001 | 1950 | https://oxomi.com/p/3000126/datasheet/-/11600031001 | 0.015828
1007550 | Tender Text en | Product URL DE | 12 | 23.7 | 0.00000312848 | REHAU Compression sleeve RAUTITAN PX 16 | 4007360361204 | 11600011001 | 1947 | https://oxomi.com/p/3000126/datasheet/-/11600011001 | 0.0076
1007552 | Tender Text en | Product URL DE | 15 | 25 | 0.00000516767 | REHAU Compression sleeve RAUTITAN PX 20 | 4007360361211 | 11600021001 | 1949 | https://oxomi.com/p/3000126/datasheet/-/11600021001 | 0.011
1007554 | Tender Text en | Product URL DE | 12 | 23.7 | 0.00000312848 | REHAU Compression sleeve RAUTITAN PX 16 | 4007360361204 | 11600011001 | 1947 | https://oxomi.com/p/3000126/datasheet/-/11600011001 | 0.0076
1007556 | Tender Text en | Product URL DE | 15 | 25 | 0.00000516767 | REHAU Compression sleeve RAUTITAN PX 20 | 4007360361211 | 11600021001 | 1949 | https://oxomi.com/p/3000126/datasheet/-/11600021001 | 0.011
1007558 | Tender Text en | Product URL DE | 20 | 27.2 | 0.0000087028 | REHAU Compression sleeve RAUTITAN PX 25 | 4007360361228 | 11600031001 | 1950 | https://oxomi.com/p/3000126/datasheet/-/11600031001 | 0.015828
1007560 | Tender Text en | Product URL DE | 15 | 25 | 0.00000516767 | REHAU Compression sleeve RAUTITAN PX 20 | 4007360361211 | 11600021001 | 1949 | https://oxomi.com/p/3000126/datasheet/-/11600021001 | 0.011
1007562 | Tender Text en | Product URL DE | 12 | 23.7 | 0.00000312848 | REHAU Compression sleeve RAUTITAN PX 16 | 4007360361204 | 11600011001 | 1947 | https://oxomi.com/p/3000126/datasheet/-/11600011001 | 0.0076
1007568 | Tender Text en | Product URL DE | 20 | 27.2 | 0.0000087028 | REHAU Compression sleeve RAUTITAN PX 25 | 4007360361228 | 11600031001 | 1950 | https://oxomi.com/p/3000126/datasheet/-/11600031001 | 0.015828
1007570 | Tender Text en | Product URL DE | 15 | 25 | 0.00000516767 | REHAU Compression sleeve RAUTITAN PX 20 | 4007360361211 | 11600021001 | 1949 | https://oxomi.com/p/3000126/datasheet/-/11600021001 | 0.011
1007572 | Tender Text en | Product URL DE | 15 | 25 | 0.00000516767 | REHAU Compression sleeve RAUTITAN PX 20 | 4007360361211 | 11600021001 | 1949 | https://oxomi.com/p/3000126/datasheet/-/11600021001 | 0.011
1007574 | Tender Text en | Product URL DE | 25 | 34 | 0.0000174355 | REHAU Compression sleeve RAUTITAN PX 32 | 4007360361235 | 11600041001 | 1951 | https://oxomi.com/p/3000126/datasheet/-/11600041001 | 0.027828
1007576 | Tender Text en | Product URL DE | 20 | 27.2 | 0.0000087028 | REHAU Compression sleeve RAUTITAN PX 25 | 4007360361228 | 11600031001 | 1950 | https://oxomi.com/p/3000126/datasheet/-/11600031001 | 0.015828
1007578 | Tender Text en | Product URL DE | 20 | 27.2 | 0.0000087028 | REHAU Compression sleeve RAUTITAN PX 25 | 4007360361228 | 11600031001 | 1950 | https://oxomi.com/p/3000126/datasheet/-/11600031001 | 0.015828
1007580 | Tender Text en | Product URL DE | 32 | 37.8 | 0.0000303041 | REHAU Compression sleeve RAUTITAN PX 40 | 4007360361242 | 11600051001 | 1952 | https://oxomi.com/p/3000126/datasheet/-/11600051001 | 0.03861
1007582 | Tender Text en | Product URL DE | 25 | 34 | 0.0000174355 | REHAU Compression sleeve RAUTITAN PX 32 | 4007360361235 | 11600041001 | 1951 | https://oxomi.com/p/3000126/datasheet/-/11600041001 | 0.027828
1007584 | Tender Text en | Product URL DE | 25 | 34 | 0.0000174355 | REHAU Compression sleeve RAUTITAN PX 32 | 4007360361235 | 11600041001 | 1951 | https://oxomi.com/p/3000126/datasheet/-/11600041001 | 0.027828
1007586 | Tender Text en | Product URL DE | 15 | 25 | 0.00000516767 | REHAU Compression sleeve RAUTITAN PX 20 | 4007360361211 | 11600021001 | 1949 | https://oxomi.com/p/3000126/datasheet/-/11600021001 | 0.011
1007588 | Tender Text en | Product URL DE | 12 | 23.7 | 0.00000312848 | REHAU Compression sleeve RAUTITAN PX 16 | 4007360361204 | 11600011001 | 1947 | https://oxomi.com/p/3000126/datasheet/-/11600011001 | 0.0076
1007590 | Tender Text en | Product URL DE | 12 | 23.7 | 0.00000312848 | REHAU Compression sleeve RAUTITAN PX 16 | 4007360361204 | 11600011001 | 1947 | https://oxomi.com/p/3000126/datasheet/-/11600011001 | 0.0076
1007592 | Tender Text en | Product URL DE | 12 | 23.7 | 0.00000312848 | REHAU Compression sleeve RAUTITAN PX 16 | 4007360361204 | 11600011001 | 1947 | https://oxomi.com/p/3000126/datasheet/-/11600011001 | 0.0076
1007594 | Tender Text en | Product URL DE | 12 | 23.7 | 0.00000312848 | REHAU Compression sleeve RAUTITAN PX 16 | 4007360361204 | 11600011001 | 1947 | https://oxomi.com/p/3000126/datasheet/-/11600011001 | 0.0076
1007598 | Tender Text en | Product URL DE | 20 | 27.2 | 0.0000087028 | REHAU Compression sleeve RAUTITAN PX 25 | 4007360361228 | 11600031001 | 1950 | https://oxomi.com/p/3000126/datasheet/-/11600031001 | 0.015828
1007600 | Tender Text en | Product URL DE | 20 | 27.2 | 0.0000087028 | REHAU Compression sleeve RAUTITAN PX 25 | 4007360361228 | 11600031001 | 1950 | https://oxomi.com/p/3000126/datasheet/-/11600031001 | 0.015828
1007602 | Tender Text en | Product URL DE | 15 | 25 | 0.00000516767 | REHAU Compression sleeve RAUTITAN PX 20 | 4007360361211 | 11600021001 | 1949 | https://oxomi.com/p/3000126/datasheet/-/11600021001 | 0.011
1007604 | Tender Text en | Product URL DE | 25 | 34 | 0.0000174355 | REHAU Compression sleeve RAUTITAN PX 32 | 4007360361235 | 11600041001 | 1951 | https://oxomi.com/p/3000126/datasheet/-/11600041001 | 0.027828
1007606 | Tender Text en | Product URL DE | 25 | 34 | 0.0000174355 | REHAU Compression sleeve RAUTITAN PX 32 | 4007360361235 | 11600041001 | 1951 | https://oxomi.com/p/3000126/datasheet/-/11600041001 | 0.027828
1007608 | Tender Text en | Product URL DE | 20 | 27.2 | 0.0000087028 | REHAU Compression sleeve RAUTITAN PX 25 | 4007360361228 | 11600031001 | 1950 | https://oxomi.com/p/3000126/datasheet/-/11600031001 | 0.015828
1007610 | Tender Text en | Product URL DE | 15 | 25 | 0.00000516767 | REHAU Compression sleeve RAUTITAN PX 20 | 4007360361211 | 11600021001 | 1949 | https://oxomi.com/p/3000126/datasheet/-/11600021001 | 0.011
1007612 | Tender Text en | Product URL DE | 15 | 25 | 0.00000516767 | REHAU Compression sleeve RAUTITAN PX 20 | 4007360361211 | 11600021001 | 1949 | https://oxomi.com/p/3000126/datasheet/-/11600021001 | 0.011
1007614 | Tender Text en | Product URL DE | 12 | 23.7 | 0.00000312848 | REHAU Compression sleeve RAUTITAN PX 16 | 4007360361204 | 11600011001 | 1947 | https://oxomi.com/p/3000126/datasheet/-/11600011001 | 0.0076
1007618 | Tender Text en | Product URL DE | 25 | 34 | 0.0000174355 | REHAU Compression sleeve RAUTITAN PX 32 | 4007360361235 | 11600041001 | 1951 | https://oxomi.com/p/3000126/datasheet/-/11600041001 | 0.027828
1007620 | Tender Text en | Product URL DE | 32 | 37.8 | 0.0000303041 | REHAU Compression sleeve RAUTITAN PX 40 | 4007360361242 | 11600051001 | 1952 | https://oxomi.com/p/3000126/datasheet/-/11600051001 | 0.03861
1007622 | Tender Text en | Product URL DE | 20 | 27.2 | 0.0000087028 | REHAU Compression sleeve RAUTITAN PX 25 | 4007360361228 | 11600031001 | 1950 | https://oxomi.com/p/3000126/datasheet/-/11600031001 | 0.015828
1007624 | Tender Text en | Product URL DE | 20 | 27.2 | 0.0000087028 | REHAU Compression sleeve RAUTITAN PX 25 | 4007360361228 | 11600031001 | 1950 | https://oxomi.com/p/3000126/datasheet/-/11600031001 | 0.015828
1007626 | Tender Text en | Product URL DE | 12 | 23.7 | 0.00000312848 | REHAU Compression sleeve RAUTITAN PX 16 | 4007360361204 | 11600011001 | 1947 | https://oxomi.com/p/3000126/datasheet/-/11600011001 | 0.0076
1007628 | Tender Text en | Product URL DE | 25 | 34 | 0.0000174355 | REHAU Compression sleeve RAUTITAN PX 32 | 4007360361235 | 11600041001 | 1951 | https://oxomi.com/p/3000126/datasheet/-/11600041001 | 0.027828
1007630 | Tender Text en | Product URL DE | 15 | 25 | 0.00000516767 | REHAU Compression sleeve RAUTITAN PX 20 | 4007360361211 | 11600021001 | 1949 | https://oxomi.com/p/3000126/datasheet/-/11600021001 | 0.011
1007632 | Tender Text en | Product URL DE | 20 | 27.2 | 0.0000087028 | REHAU Compression sleeve RAUTITAN PX 25 | 4007360361228 | 11600031001 | 1950 | https://oxomi.com/p/3000126/datasheet/-/11600031001 | 0.015828
1078155 | Tender Text nl | Product URL NL | 12 | 23.7 | 0.00000312848 | REHAU Compression sleeve RAUTITAN PX 16 | 4007360361204 | 11600011001 | 1947 | https://oxomi.com/p/3001042/datasheet/-/11600011001 | 0.0076
1078159 | Tender Text nl | Product URL NL | 15 | 25 | 0.00000516767 | REHAU Compression sleeve RAUTITAN PX 20 | 4007360361211 | 11600021001 | 1949 | https://oxomi.com/p/3001042/datasheet/-/11600021001 | 0.011
1078476 | Tender Text en | Product URL DE | 12 | 23.7 | 0.00000312848 | REHAU Compression sleeve RAUTITAN PX 16 | 4007360361204 | 11600011001 | 1947 | https://oxomi.com/p/3000126/datasheet/-/11600011001 | 0.0076
1078478 | Tender Text en | Product URL DE | 12 | 23.7 | 0.00000312848 | REHAU Compression sleeve RAUTITAN PX 16 | 4007360361204 | 11600011001 | 1947 | https://oxomi.com/p/3000126/datasheet/-/11600011001 | 0.0076
1078480 | Tender Text en | Product URL DE | 15 | 25 | 0.00000516767 | REHAU Compression sleeve RAUTITAN PX 20 | 4007360361211 | 11600021001 | 1949 | https://oxomi.com/p/3000126/datasheet/-/11600021001 | 0.011
1078482 | Tender Text en | Product URL DE | 15 | 25 | 0.00000516767 | REHAU Compression sleeve RAUTITAN PX 20 | 4007360361211 | 11600021001 | 1949 | https://oxomi.com/p/3000126/datasheet/-/11600021001 | 0.011
1078484 | Tender Text en | Product URL DE | 20 | 27.2 | 0.0000087028 | REHAU Compression sleeve RAUTITAN PX 25 | 4007360361228 | 11600031001 | 1950 | https://oxomi.com/p/3000126/datasheet/-/11600031001 | 0.015828
1078486 | Tender Text en | Product URL DE | 20 | 27.2 | 0.0000087028 | REHAU Compression sleeve RAUTITAN PX 25 | 4007360361228 | 11600031001 | 1950 | https://oxomi.com/p/3000126/datasheet/-/11600031001 | 0.015828
1078488 | Tender Text en | Product URL DE | 25 | 34 | 0.0000174355 | REHAU Compression sleeve RAUTITAN PX 32 | 4007360361235 | 11600041001 | 1951 | https://oxomi.com/p/3000126/datasheet/-/11600041001 | 0.027828
1078490 | Tender Text en | Product URL DE | 25 | 34 | 0.0000174355 | REHAU Compression sleeve RAUTITAN PX 32 | 4007360361235 | 11600041001 | 1951 | https://oxomi.com/p/3000126/datasheet/-/11600041001 | 0.027828
1078492 | Tender Text en | Product URL DE | 32 | 37.8 | 0.0000303041 | REHAU Compression sleeve RAUTITAN PX 40 | 4007360361242 | 11600051001 | 1952 | https://oxomi.com/p/3000126/datasheet/-/11600051001 | 0.03861
1078494 | Tender Text en | Product URL DE | 32 | 37.8 | 0.0000303041 | REHAU Compression sleeve RAUTITAN PX 40 | 4007360361242 | 11600051001 | 1952 | https://oxomi.com/p/3000126/datasheet/-/11600051001 | 0.03861
1078496 | Tender Text en | Product URL DE | 15 | 25 | 0.00000516767 | REHAU Compression sleeve RAUTITAN PX 20 | 4007360361211 | 11600021001 | 1949 | https://oxomi.com/p/3000126/datasheet/-/11600021001 | 0.011
1078498 | Tender Text en | Product URL DE | 15 | 25 | 0.00000516767 | REHAU Compression sleeve RAUTITAN PX 20 | 4007360361211 | 11600021001 | 1949 | https://oxomi.com/p/3000126/datasheet/-/11600021001 | 0.011
1078500 | Tender Text en | Product URL DE | 20 | 27.2 | 0.0000087028 | REHAU Compression sleeve RAUTITAN PX 25 | 4007360361228 | 11600031001 | 1950 | https://oxomi.com/p/3000126/datasheet/-/11600031001 | 0.015828
1078502 | Tender Text en | Product URL DE | 20 | 27.2 | 0.0000087028 | REHAU Compression sleeve RAUTITAN PX 25 | 4007360361228 | 11600031001 | 1950 | https://oxomi.com/p/3000126/datasheet/-/11600031001 | 0.015828
1078504 | Tender Text en | Product URL DE | 25 | 34 | 0.0000174355 | REHAU Compression sleeve RAUTITAN PX 32 | 4007360361235 | 11600041001 | 1951 | https://oxomi.com/p/3000126/datasheet/-/11600041001 | 0.027828
1078506 | Tender Text en | Product URL DE | 25 | 34 | 0.0000174355 | REHAU Compression sleeve RAUTITAN PX 32 | 4007360361235 | 11600041001 | 1951 | https://oxomi.com/p/3000126/datasheet/-/11600041001 | 0.027828
1078508 | Tender Text en | Product URL DE | 32 | 37.8 | 0.0000303041 | REHAU Compression sleeve RAUTITAN PX 40 | 4007360361242 | 11600051001 | 1952 | https://oxomi.com/p/3000126/datasheet/-/11600051001 | 0.03861
1078510 | Tender Text en | Product URL DE | 32 | 37.8 | 0.0000303041 | REHAU Compression sleeve RAUTITAN PX 40 | 4007360361242 | 11600051001 | 1952 | https://oxomi.com/p/3000126/datasheet/-/11600051001 | 0.03861
1078512 | Tender Text en | Product URL DE | 40 | 45 | 0.0000353695 | REHAU Compr. sleeve RAUTITAN PX stabil 50 | 4062178755416 | 11602061001 | 1954 | https://oxomi.com/p/3000126/datasheet/-/11602061001 | 0.0673
1078514 | Tender Text en | Product URL DE | 40 | 45 | 0.0000353695 | REHAU Compr. sleeve RAUTITAN PX stabil 50 | 4062178755416 | 11602061001 | 1954 | https://oxomi.com/p/3000126/datasheet/-/11602061001 | 0.0673
1078516 | Tender Text en | Product URL DE | 50 | 53 | 0.0000702282 | REHAU Compr. sleeve RAUTITAN PX stabil 63 | 4062178755423 | 11602071001 | 1955 | https://oxomi.com/p/3000126/datasheet/-/11602071001 | 0.1106
1078518 | Tender Text en | Product URL DE | 50 | 53 | 0.0000702282 | REHAU Compr. sleeve RAUTITAN PX stabil 63 | 4062178755423 | 11602071001 | 1955 | https://oxomi.com/p/3000126/datasheet/-/11602071001 | 0.1106
1078520 | Tender Text en | Product URL DE | 50 | 53 | 0.0000702282 | REHAU Compr. sleeve RAUTITAN PX stabil 63 | 4062178755423 | 11602071001 | 1955 | https://oxomi.com/p/3000126/datasheet/-/11602071001 | 0.1106
1078522 | Tender Text en | Product URL DE | 50 | 53 | 0.0000702282 | REHAU Compr. sleeve RAUTITAN PX stabil 63 | 4062178755423 | 11602071001 | 1955 | https://oxomi.com/p/3000126/datasheet/-/11602071001 | 0.1106
1078524 | Tender Text en | Product URL DE | 40 | 45 | 0.0000353695 | REHAU Compr. sleeve RAUTITAN PX stabil 50 | 4062178755416 | 11602061001 | 1954 | https://oxomi.com/p/3000126/datasheet/-/11602061001 | 0.0673
1078526 | Tender Text en | Product URL DE | 40 | 45 | 0.0000353695 | REHAU Compr. sleeve RAUTITAN PX stabil 50 | 4062178755416 | 11602061001 | 1954 | https://oxomi.com/p/3000126/datasheet/-/11602061001 | 0.0673
1078528 | Tender Text en | Product URL DE | 12 | 23.7 | 0.00000312848 | REHAU Compression sleeve RAUTITAN PX 16 | 4007360361204 | 11600011001 | 1947 | https://oxomi.com/p/3000126/datasheet/-/11600011001 | 0.0076
1078530 | Tender Text en | Product URL DE | 12 | 23.7 | 0.00000312848 | REHAU Compression sleeve RAUTITAN PX 16 | 4007360361204 | 11600011001 | 1947 | https://oxomi.com/p/3000126/datasheet/-/11600011001 | 0.0076
1078532 | Tender Text en | Product URL DE | 15 | 25 | 0.00000516767 | REHAU Compression sleeve RAUTITAN PX 20 | 4007360361211 | 11600021001 | 1949 | https://oxomi.com/p/3000126/datasheet/-/11600021001 | 0.011
1078534 | Tender Text en | Product URL DE | 15 | 25 | 0.00000516767 | REHAU Compression sleeve RAUTITAN PX 20 | 4007360361211 | 11600021001 | 1949 | https://oxomi.com/p/3000126/datasheet/-/11600021001 | 0.011
1078536 | Tender Text en | Product URL DE | 20 | 27.2 | 0.0000087028 | REHAU Compression sleeve RAUTITAN PX 25 | 4007360361228 | 11600031001 | 1950 | https://oxomi.com/p/3000126/datasheet/-/11600031001 | 0.015828
1078538 | Tender Text en | Product URL DE | 20 | 27.2 | 0.0000087028 | REHAU Compression sleeve RAUTITAN PX 25 | 4007360361228 | 11600031001 | 1950 | https://oxomi.com/p/3000126/datasheet/-/11600031001 | 0.015828
1078540 | Tender Text en | Product URL DE | 25 | 34 | 0.0000174355 | REHAU Compression sleeve RAUTITAN PX 32 | 4007360361235 | 11600041001 | 1951 | https://oxomi.com/p/3000126/datasheet/-/11600041001 | 0.027828
1078542 | Tender Text en | Product URL DE | 25 | 34 | 0.0000174355 | REHAU Compression sleeve RAUTITAN PX 32 | 4007360361235 | 11600041001 | 1951 | https://oxomi.com/p/3000126/datasheet/-/11600041001 | 0.027828
1078562 | Tender Text nl | Product URL NL | 15 | 25 | 0.00000516767 | REHAU Compression sleeve RAUTITAN PX 20 | 4007360361211 | 11600021001 | 1949 | https://oxomi.com/p/3001042/datasheet/-/11600021001 | 0.011
1078566 | Tender Text nl | Product URL NL | 20 | 27.2 | 0.0000087028 | REHAU Compression sleeve RAUTITAN PX 25 | 4007360361228 | 11600031001 | 1950 | https://oxomi.com/p/3001042/datasheet/-/11600031001 | 0.015828
1078569 | Tender Text en | Product URL DE | 12 | 23.7 | 0.00000312848 | REHAU Compression sleeve RAUTITAN PX 16 | 4007360361204 | 11600011001 | 1947 | https://oxomi.com/p/3000126/datasheet/-/11600011001 | 0.0076
1078571 | Tender Text en | Product URL DE | 12 | 23.7 | 0.00000312848 | REHAU Compression sleeve RAUTITAN PX 16 | 4007360361204 | 11600011001 | 1947 | https://oxomi.com/p/3000126/datasheet/-/11600011001 | 0.0076
1078573 | Tender Text en | Product URL DE | 12 | 23.7 | 0.00000312848 | REHAU Compression sleeve RAUTITAN PX 16 | 4007360361204 | 11600011001 | 1947 | https://oxomi.com/p/3000126/datasheet/-/11600011001 | 0.0076
1078575 | Tender Text en | Product URL DE | 20 | 27.2 | 0.0000087028 | REHAU Compression sleeve RAUTITAN PX 25 | 4007360361228 | 11600031001 | 1950 | https://oxomi.com/p/3000126/datasheet/-/11600031001 | 0.015828
1078577 | Tender Text en | Product URL DE | 20 | 27.2 | 0.0000087028 | REHAU Compression sleeve RAUTITAN PX 25 | 4007360361228 | 11600031001 | 1950 | https://oxomi.com/p/3000126/datasheet/-/11600031001 | 0.015828
1078579 | Tender Text en | Product URL DE | 20 | 27.2 | 0.0000087028 | REHAU Compression sleeve RAUTITAN PX 25 | 4007360361228 | 11600031001 | 1950 | https://oxomi.com/p/3000126/datasheet/-/11600031001 | 0.015828
1078581 | Tender Text en | Product URL DE | 25 | 34 | 0.0000174355 | REHAU Compression sleeve RAUTITAN PX 32 | 4007360361235 | 11600041001 | 1951 | https://oxomi.com/p/3000126/datasheet/-/11600041001 | 0.027828
1078583 | Tender Text en | Product URL DE | 25 | 34 | 0.0000174355 | REHAU Compression sleeve RAUTITAN PX 32 | 4007360361235 | 11600041001 | 1951 | https://oxomi.com/p/3000126/datasheet/-/11600041001 | 0.027828
1078585 | Tender Text en | Product URL DE | 25 | 34 | 0.0000174355 | REHAU Compression sleeve RAUTITAN PX 32 | 4007360361235 | 11600041001 | 1951 | https://oxomi.com/p/3000126/datasheet/-/11600041001 | 0.027828
1078587 | Tender Text en | Product URL DE | 32 | 37.8 | 0.0000303041 | REHAU Compression sleeve RAUTITAN PX 40 | 4007360361242 | 11600051001 | 1952 | https://oxomi.com/p/3000126/datasheet/-/11600051001 | 0.03861
1078589 | Tender Text en | Product URL DE | 32 | 37.8 | 0.0000303041 | REHAU Compression sleeve RAUTITAN PX 40 | 4007360361242 | 11600051001 | 1952 | https://oxomi.com/p/3000126/datasheet/-/11600051001 | 0.03861
1078591 | Tender Text en | Product URL DE | 32 | 37.8 | 0.0000303041 | REHAU Compression sleeve RAUTITAN PX 40 | 4007360361242 | 11600051001 | 1952 | https://oxomi.com/p/3000126/datasheet/-/11600051001 | 0.03861
1078593 | Tender Text en | Product URL DE | 15 | 25 | 0.00000516767 | REHAU Compression sleeve RAUTITAN PX 20 | 4007360361211 | 11600021001 | 1949 | https://oxomi.com/p/3000126/datasheet/-/11600021001 | 0.011
1078595 | Tender Text en | Product URL DE | 15 | 25 | 0.00000516767 | REHAU Compression sleeve RAUTITAN PX 20 | 4007360361211 | 11600021001 | 1949 | https://oxomi.com/p/3000126/datasheet/-/11600021001 | 0.011
1078597 | Tender Text en | Product URL DE | 15 | 25 | 0.00000516767 | REHAU Compression sleeve RAUTITAN PX 20 | 4007360361211 | 11600021001 | 1949 | https://oxomi.com/p/3000126/datasheet/-/11600021001 | 0.011
1078599 | Tender Text en | Product URL DE | 20 | 27.2 | 0.0000087028 | REHAU Compression sleeve RAUTITAN PX 25 | 4007360361228 | 11600031001 | 1950 | https://oxomi.com/p/3000126/datasheet/-/11600031001 | 0.015828
1078601 | Tender Text en | Product URL DE | 15 | 25 | 0.00000516767 | REHAU Compression sleeve RAUTITAN PX 20 | 4007360361211 | 11600021001 | 1949 | https://oxomi.com/p/3000126/datasheet/-/11600021001 | 0.011
1078603 | Tender Text en | Product URL DE | 20 | 27.2 | 0.0000087028 | REHAU Compression sleeve RAUTITAN PX 25 | 4007360361228 | 11600031001 | 1950 | https://oxomi.com/p/3000126/datasheet/-/11600031001 | 0.015828
1078605 | Tender Text en | Product URL DE | 25 | 34 | 0.0000174355 | REHAU Compression sleeve RAUTITAN PX 32 | 4007360361235 | 11600041001 | 1951 | https://oxomi.com/p/3000126/datasheet/-/11600041001 | 0.027828
1078607 | Tender Text en | Product URL DE | 20 | 27.2 | 0.0000087028 | REHAU Compression sleeve RAUTITAN PX 25 | 4007360361228 | 11600031001 | 1950 | https://oxomi.com/p/3000126/datasheet/-/11600031001 | 0.015828
1078609 | Tender Text en | Product URL DE | 25 | 34 | 0.0000174355 | REHAU Compression sleeve RAUTITAN PX 32 | 4007360361235 | 11600041001 | 1951 | https://oxomi.com/p/3000126/datasheet/-/11600041001 | 0.027828
1078611 | Tender Text en | Product URL DE | 32 | 37.8 | 0.0000303041 | REHAU Compression sleeve RAUTITAN PX 40 | 4007360361242 | 11600051001 | 1952 | https://oxomi.com/p/3000126/datasheet/-/11600051001 | 0.03861
1078613 | Tender Text en | Product URL DE | 25 | 34 | 0.0000174355 | REHAU Compression sleeve RAUTITAN PX 32 | 4007360361235 | 11600041001 | 1951 | https://oxomi.com/p/3000126/datasheet/-/11600041001 | 0.027828
1078615 | Tender Text en | Product URL DE | 32 | 37.8 | 0.0000303041 | REHAU Compression sleeve RAUTITAN PX 40 | 4007360361242 | 11600051001 | 1952 | https://oxomi.com/p/3000126/datasheet/-/11600051001 | 0.03861
1078617 | Tender Text en | Product URL DE | 15 | 25 | 0.00000516767 | REHAU Compression sleeve RAUTITAN PX 20 | 4007360361211 | 11600021001 | 1949 | https://oxomi.com/p/3000126/datasheet/-/11600021001 | 0.011
1078619 | Tender Text en | Product URL DE | 12 | 23.7 | 0.00000312848 | REHAU Compression sleeve RAUTITAN PX 16 | 4007360361204 | 11600011001 | 1947 | https://oxomi.com/p/3000126/datasheet/-/11600011001 | 0.0076
1078621 | Tender Text en | Product URL DE | 15 | 25 | 0.00000516767 | REHAU Compression sleeve RAUTITAN PX 20 | 4007360361211 | 11600021001 | 1949 | https://oxomi.com/p/3000126/datasheet/-/11600021001 | 0.011
1078623 | Tender Text en | Product URL DE | 20 | 27.2 | 0.0000087028 | REHAU Compression sleeve RAUTITAN PX 25 | 4007360361228 | 11600031001 | 1950 | https://oxomi.com/p/3000126/datasheet/-/11600031001 | 0.015828
1078625 | Tender Text en | Product URL DE | 12 | 23.7 | 0.00000312848 | REHAU Compression sleeve RAUTITAN PX 16 | 4007360361204 | 11600011001 | 1947 | https://oxomi.com/p/3000126/datasheet/-/11600011001 | 0.0076
1078627 | Tender Text en | Product URL DE | 20 | 27.2 | 0.0000087028 | REHAU Compression sleeve RAUTITAN PX 25 | 4007360361228 | 11600031001 | 1950 | https://oxomi.com/p/3000126/datasheet/-/11600031001 | 0.015828
1078629 | Tender Text en | Product URL DE | 25 | 34 | 0.0000174355 | REHAU Compression sleeve RAUTITAN PX 32 | 4007360361235 | 11600041001 | 1951 | https://oxomi.com/p/3000126/datasheet/-/11600041001 | 0.027828
1078631 | Tender Text en | Product URL DE | 15 | 25 | 0.00000516767 | REHAU Compression sleeve RAUTITAN PX 20 | 4007360361211 | 11600021001 | 1949 | https://oxomi.com/p/3000126/datasheet/-/11600021001 | 0.011
1078633 | Tender Text en | Product URL DE | 25 | 34 | 0.0000174355 | REHAU Compression sleeve RAUTITAN PX 32 | 4007360361235 | 11600041001 | 1951 | https://oxomi.com/p/3000126/datasheet/-/11600041001 | 0.027828
1078635 | Tender Text en | Product URL DE | 32 | 37.8 | 0.0000303041 | REHAU Compression sleeve RAUTITAN PX 40 | 4007360361242 | 11600051001 | 1952 | https://oxomi.com/p/3000126/datasheet/-/11600051001 | 0.03861
1078637 | Tender Text en | Product URL DE | 20 | 27.2 | 0.0000087028 | REHAU Compression sleeve RAUTITAN PX 25 | 4007360361228 | 11600031001 | 1950 | https://oxomi.com/p/3000126/datasheet/-/11600031001 | 0.015828
1078639 | Tender Text en | Product URL DE | 32 | 37.8 | 0.0000303041 | REHAU Compression sleeve RAUTITAN PX 40 | 4007360361242 | 11600051001 | 1952 | https://oxomi.com/p/3000126/datasheet/-/11600051001 | 0.03861
1078641 | Tender Text en | Product URL DE | 25 | 34 | 0.0000174355 | REHAU Compression sleeve RAUTITAN PX 32 | 4007360361235 | 11600041001 | 1951 | https://oxomi.com/p/3000126/datasheet/-/11600041001 | 0.027828
1078643 | Tender Text en | Product URL DE | 12 | 23.7 | 0.00000312848 | REHAU Compression sleeve RAUTITAN PX 16 | 4007360361204 | 11600011001 | 1947 | https://oxomi.com/p/3000126/datasheet/-/11600011001 | 0.0076
1078645 | Tender Text en | Product URL DE | 25 | 34 | 0.0000174355 | REHAU Compression sleeve RAUTITAN PX 32 | 4007360361235 | 11600041001 | 1951 | https://oxomi.com/p/3000126/datasheet/-/11600041001 | 0.027828
1078647 | Tender Text en | Product URL DE | 32 | 37.8 | 0.0000303041 | REHAU Compression sleeve RAUTITAN PX 40 | 4007360361242 | 11600051001 | 1952 | https://oxomi.com/p/3000126/datasheet/-/11600051001 | 0.03861
1078649 | Tender Text en | Product URL DE | 15 | 25 | 0.00000516767 | REHAU Compression sleeve RAUTITAN PX 20 | 4007360361211 | 11600021001 | 1949 | https://oxomi.com/p/3000126/datasheet/-/11600021001 | 0.011
1078651 | Tender Text en | Product URL DE | 32 | 37.8 | 0.0000303041 | REHAU Compression sleeve RAUTITAN PX 40 | 4007360361242 | 11600051001 | 1952 | https://oxomi.com/p/3000126/datasheet/-/11600051001 | 0.03861
1078653 | Tender Text en | Product URL DE | 12 | 23.7 | 0.00000312848 | REHAU Compression sleeve RAUTITAN PX 16 | 4007360361204 | 11600011001 | 1947 | https://oxomi.com/p/3000126/datasheet/-/11600011001 | 0.0076
1078655 | Tender Text en | Product URL DE | 15 | 25 | 0.00000516767 | REHAU Compression sleeve RAUTITAN PX 20 | 4007360361211 | 11600021001 | 1949 | https://oxomi.com/p/3000126/datasheet/-/11600021001 | 0.011
1078657 | Tender Text en | Product URL DE | 12 | 23.7 | 0.00000312848 | REHAU Compression sleeve RAUTITAN PX 16 | 4007360361204 | 11600011001 | 1947 | https://oxomi.com/p/3000126/datasheet/-/11600011001 | 0.0076
1078659 | Tender Text en | Product URL DE | 20 | 27.2 | 0.0000087028 | REHAU Compression sleeve RAUTITAN PX 25 | 4007360361228 | 11600031001 | 1950 | https://oxomi.com/p/3000126/datasheet/-/11600031001 | 0.015828
1078661 | Tender Text en | Product URL DE | 25 | 34 | 0.0000174355 | REHAU Compression sleeve RAUTITAN PX 32 | 4007360361235 | 11600041001 | 1951 | https://oxomi.com/p/3000126/datasheet/-/11600041001 | 0.027828
1078663 | Tender Text en | Product URL DE | 20 | 27.2 | 0.0000087028 | REHAU Compression sleeve RAUTITAN PX 25 | 4007360361228 | 11600031001 | 1950 | https://oxomi.com/p/3000126/datasheet/-/11600031001 | 0.015828
1078665 | Tender Text en | Product URL DE | 15 | 25 | 0.00000516767 | REHAU Compression sleeve RAUTITAN PX 20 | 4007360361211 | 11600021001 | 1949 | https://oxomi.com/p/3000126/datasheet/-/11600021001 | 0.011
1078667 | Tender Text en | Product URL DE | 20 | 27.2 | 0.0000087028 | REHAU Compression sleeve RAUTITAN PX 25 | 4007360361228 | 11600031001 | 1950 | https://oxomi.com/p/3000126/datasheet/-/11600031001 | 0.015828
1078669 | Tender Text en | Product URL DE | 15 | 25 | 0.00000516767 | REHAU Compression sleeve RAUTITAN PX 20 | 4007360361211 | 11600021001 | 1949 | https://oxomi.com/p/3000126/datasheet/-/11600021001 | 0.011
1078671 | Tender Text en | Product URL DE | 12 | 23.7 | 0.00000312848 | REHAU Compression sleeve RAUTITAN PX 16 | 4007360361204 | 11600011001 | 1947 | https://oxomi.com/p/3000126/datasheet/-/11600011001 | 0.0076
1078673 | Tender Text en | Product URL DE | 20 | 27.2 | 0.0000087028 | REHAU Compression sleeve RAUTITAN PX 25 | 4007360361228 | 11600031001 | 1950 | https://oxomi.com/p/3000126/datasheet/-/11600031001 | 0.015828
1078675 | Tender Text en | Product URL DE | 12 | 23.7 | 0.00000312848 | REHAU Compression sleeve RAUTITAN PX 16 | 4007360361204 | 11600011001 | 1947 | https://oxomi.com/p/3000126/datasheet/-/11600011001 | 0.0076
1078677 | Tender Text en | Product URL DE | 15 | 25 | 0.00000516767 | REHAU Compression sleeve RAUTITAN PX 20 | 4007360361211 | 11600021001 | 1949 | https://oxomi.com/p/3000126/datasheet/-/11600021001 | 0.011
1078679 | Tender Text en | Product URL DE | 12 | 23.7 | 0.00000312848 | REHAU Compression sleeve RAUTITAN PX 16 | 4007360361204 | 11600011001 | 1947 | https://oxomi.com/p/3000126/datasheet/-/11600011001 | 0.0076
1078681 | Tender Text en | Product URL DE | 12 | 23.7 | 0.00000312848 | REHAU Compression sleeve RAUTITAN PX 16 | 4007360361204 | 11600011001 | 1947 | https://oxomi.com/p/3000126/datasheet/-/11600011001 | 0.0076
1078683 | Tender Text en | Product URL DE | 20 | 27.2 | 0.0000087028 | REHAU Compression sleeve RAUTITAN PX 25 | 4007360361228 | 11600031001 | 1950 | https://oxomi.com/p/3000126/datasheet/-/11600031001 | 0.015828
1078685 | Tender Text en | Product URL DE | 15 | 25 | 0.00000516767 | REHAU Compression sleeve RAUTITAN PX 20 | 4007360361211 | 11600021001 | 1949 | https://oxomi.com/p/3000126/datasheet/-/11600021001 | 0.011
1078687 | Tender Text en | Product URL DE | 15 | 25 | 0.00000516767 | REHAU Compression sleeve RAUTITAN PX 20 | 4007360361211 | 11600021001 | 1949 | https://oxomi.com/p/3000126/datasheet/-/11600021001 | 0.011
1078689 | Tender Text en | Product URL DE | 25 | 34 | 0.0000174355 | REHAU Compression sleeve RAUTITAN PX 32 | 4007360361235 | 11600041001 | 1951 | https://oxomi.com/p/3000126/datasheet/-/11600041001 | 0.027828
1078691 | Tender Text en | Product URL DE | 20 | 27.2 | 0.0000087028 | REHAU Compression sleeve RAUTITAN PX 25 | 4007360361228 | 11600031001 | 1950 | https://oxomi.com/p/3000126/datasheet/-/11600031001 | 0.015828
1078693 | Tender Text en | Product URL DE | 20 | 27.2 | 0.0000087028 | REHAU Compression sleeve RAUTITAN PX 25 | 4007360361228 | 11600031001 | 1950 | https://oxomi.com/p/3000126/datasheet/-/11600031001 | 0.015828
1078695 | Tender Text en | Product URL DE | 32 | 37.8 | 0.0000303041 | REHAU Compression sleeve RAUTITAN PX 40 | 4007360361242 | 11600051001 | 1952 | https://oxomi.com/p/3000126/datasheet/-/11600051001 | 0.03861
1078697 | Tender Text en | Product URL DE | 25 | 34 | 0.0000174355 | REHAU Compression sleeve RAUTITAN PX 32 | 4007360361235 | 11600041001 | 1951 | https://oxomi.com/p/3000126/datasheet/-/11600041001 | 0.027828
1078699 | Tender Text en | Product URL DE | 25 | 34 | 0.0000174355 | REHAU Compression sleeve RAUTITAN PX 32 | 4007360361235 | 11600041001 | 1951 | https://oxomi.com/p/3000126/datasheet/-/11600041001 | 0.027828
1078701 | Tender Text en | Product URL DE | 20 | 27.2 | 0.0000087028 | REHAU Compression sleeve RAUTITAN PX 25 | 4007360361228 | 11600031001 | 1950 | https://oxomi.com/p/3000126/datasheet/-/11600031001 | 0.015828
1078703 | Tender Text en | Product URL DE | 12 | 23.7 | 0.00000312848 | REHAU Compression sleeve RAUTITAN PX 16 | 4007360361204 | 11600011001 | 1947 | https://oxomi.com/p/3000126/datasheet/-/11600011001 | 0.0076
1078705 | Tender Text en | Product URL DE | 12 | 23.7 | 0.00000312848 | REHAU Compression sleeve RAUTITAN PX 16 | 4007360361204 | 11600011001 | 1947 | https://oxomi.com/p/3000126/datasheet/-/11600011001 | 0.0076
1078707 | Tender Text en | Product URL DE | 25 | 34 | 0.0000174355 | REHAU Compression sleeve RAUTITAN PX 32 | 4007360361235 | 11600041001 | 1951 | https://oxomi.com/p/3000126/datasheet/-/11600041001 | 0.027828
1078709 | Tender Text en | Product URL DE | 15 | 25 | 0.00000516767 | REHAU Compression sleeve RAUTITAN PX 20 | 4007360361211 | 11600021001 | 1949 | https://oxomi.com/p/3000126/datasheet/-/11600021001 | 0.011
1078711 | Tender Text en | Product URL DE | 15 | 25 | 0.00000516767 | REHAU Compression sleeve RAUTITAN PX 20 | 4007360361211 | 11600021001 | 1949 | https://oxomi.com/p/3000126/datasheet/-/11600021001 | 0.011
1078713 | Tender Text en | Product URL DE | 15 | 25 | 0.00000516767 | REHAU Compression sleeve RAUTITAN PX 20 | 4007360361211 | 11600021001 | 1949 | https://oxomi.com/p/3000126/datasheet/-/11600021001 | 0.011
1078715 | Tender Text en | Product URL DE | 15 | 25 | 0.00000516767 | REHAU Compression sleeve RAUTITAN PX 20 | 4007360361211 | 11600021001 | 1949 | https://oxomi.com/p/3000126/datasheet/-/11600021001 | 0.011
1078717 | Tender Text en | Product URL DE | 12 | 23.7 | 0.00000312848 | REHAU Compression sleeve RAUTITAN PX 16 | 4007360361204 | 11600011001 | 1947 | https://oxomi.com/p/3000126/datasheet/-/11600011001 | 0.0076
1078719 | Tender Text en | Product URL DE | 20 | 27.2 | 0.0000087028 | REHAU Compression sleeve RAUTITAN PX 25 | 4007360361228 | 11600031001 | 1950 | https://oxomi.com/p/3000126/datasheet/-/11600031001 | 0.015828
1078721 | Tender Text en | Product URL DE | 20 | 27.2 | 0.0000087028 | REHAU Compression sleeve RAUTITAN PX 25 | 4007360361228 | 11600031001 | 1950 | https://oxomi.com/p/3000126/datasheet/-/11600031001 | 0.015828
1078723 | Tender Text en | Product URL DE | 15 | 25 | 0.00000516767 | REHAU Compression sleeve RAUTITAN PX 20 | 4007360361211 | 11600021001 | 1949 | https://oxomi.com/p/3000126/datasheet/-/11600021001 | 0.011
1078725 | Tender Text en | Product URL DE | 25 | 34 | 0.0000174355 | REHAU Compression sleeve RAUTITAN PX 32 | 4007360361235 | 11600041001 | 1951 | https://oxomi.com/p/3000126/datasheet/-/11600041001 | 0.027828
1078727 | Tender Text en | Product URL DE | 25 | 34 | 0.0000174355 | REHAU Compression sleeve RAUTITAN PX 32 | 4007360361235 | 11600041001 | 1951 | https://oxomi.com/p/3000126/datasheet/-/11600041001 | 0.027828
1078729 | Tender Text en | Product URL DE | 20 | 27.2 | 0.0000087028 | REHAU Compression sleeve RAUTITAN PX 25 | 4007360361228 | 11600031001 | 1950 | https://oxomi.com/p/3000126/datasheet/-/11600031001 | 0.015828
1078731 | Tender Text en | Product URL DE | 20 | 27.2 | 0.0000087028 | REHAU Compression sleeve RAUTITAN PX 25 | 4007360361228 | 11600031001 | 1950 | https://oxomi.com/p/3000126/datasheet/-/11600031001 | 0.015828
1078733 | Tender Text en | Product URL DE | 20 | 27.2 | 0.0000087028 | REHAU Compression sleeve RAUTITAN PX 25 | 4007360361228 | 11600031001 | 1950 | https://oxomi.com/p/3000126/datasheet/-/11600031001 | 0.015828
1078735 | Tender Text en | Product URL DE | 12 | 23.7 | 0.00000312848 | REHAU Compression sleeve RAUTITAN PX 16 | 4007360361204 | 11600011001 | 1947 | https://oxomi.com/p/3000126/datasheet/-/11600011001 | 0.0076
1078737 | Tender Text en | Product URL DE | 25 | 34 | 0.0000174355 | REHAU Compression sleeve RAUTITAN PX 32 | 4007360361235 | 11600041001 | 1951 | https://oxomi.com/p/3000126/datasheet/-/11600041001 | 0.027828
1078739 | Tender Text en | Product URL DE | 25 | 34 | 0.0000174355 | REHAU Compression sleeve RAUTITAN PX 32 | 4007360361235 | 11600041001 | 1951 | https://oxomi.com/p/3000126/datasheet/-/11600041001 | 0.027828
1078741 | Tender Text en | Product URL DE | 15 | 25 | 0.00000516767 | REHAU Compression sleeve RAUTITAN PX 20 | 4007360361211 | 11600021001 | 1949 | https://oxomi.com/p/3000126/datasheet/-/11600021001 | 0.011
1078743 | Tender Text en | Product URL DE | 15 | 25 | 0.00000516767 | REHAU Compression sleeve RAUTITAN PX 20 | 4007360361211 | 11600021001 | 1949 | https://oxomi.com/p/3000126/datasheet/-/11600021001 | 0.011
1078745 | Tender Text en | Product URL DE | 20 | 27.2 | 0.0000087028 | REHAU Compression sleeve RAUTITAN PX 25 | 4007360361228 | 11600031001 | 1950 | https://oxomi.com/p/3000126/datasheet/-/11600031001 | 0.015828
1078747 | Tender Text en | Product URL DE | 12 | 23.7 | 0.00000312848 | REHAU Compression sleeve RAUTITAN PX 16 | 4007360361204 | 11600011001 | 1947 | https://oxomi.com/p/3000126/datasheet/-/11600011001 | 0.0076
1078749 | Tender Text en | Product URL DE | 20 | 27.2 | 0.0000087028 | REHAU Compression sleeve RAUTITAN PX 25 | 4007360361228 | 11600031001 | 1950 | https://oxomi.com/p/3000126/datasheet/-/11600031001 | 0.015828
1078751 | Tender Text en | Product URL DE | 12 | 23.7 | 0.00000312848 | REHAU Compression sleeve RAUTITAN PX 16 | 4007360361204 | 11600011001 | 1947 | https://oxomi.com/p/3000126/datasheet/-/11600011001 | 0.0076
1078753 | Tender Text en | Product URL DE | 15 | 25 | 0.00000516767 | REHAU Compression sleeve RAUTITAN PX 20 | 4007360361211 | 11600021001 | 1949 | https://oxomi.com/p/3000126/datasheet/-/11600021001 | 0.011
1078755 | Tender Text en | Product URL DE | 25 | 34 | 0.0000174355 | REHAU Compression sleeve RAUTITAN PX 32 | 4007360361235 | 11600041001 | 1951 | https://oxomi.com/p/3000126/datasheet/-/11600041001 | 0.027828
1078757 | Tender Text en | Product URL DE | 15 | 25 | 0.00000516767 | REHAU Compression sleeve RAUTITAN PX 20 | 4007360361211 | 11600021001 | 1949 | https://oxomi.com/p/3000126/datasheet/-/11600021001 | 0.011
1078759 | Tender Text en | Product URL DE | 20 | 27.2 | 0.0000087028 | REHAU Compression sleeve RAUTITAN PX 25 | 4007360361228 | 11600031001 | 1950 | https://oxomi.com/p/3000126/datasheet/-/11600031001 | 0.015828
1078761 | Tender Text en | Product URL DE | 20 | 27.2 | 0.0000087028 | REHAU Compression sleeve RAUTITAN PX 25 | 4007360361228 | 11600031001 | 1950 | https://oxomi.com/p/3000126/datasheet/-/11600031001 | 0.015828
1078763 | Tender Text en | Product URL DE | 15 | 25 | 0.00000516767 | REHAU Compression sleeve RAUTITAN PX 20 | 4007360361211 | 11600021001 | 1949 | https://oxomi.com/p/3000126/datasheet/-/11600021001 | 0.011
1078765 | Tender Text en | Product URL DE | 12 | 23.7 | 0.00000312848 | REHAU Compression sleeve RAUTITAN PX 16 | 4007360361204 | 11600011001 | 1947 | https://oxomi.com/p/3000126/datasheet/-/11600011001 | 0.0076
1078767 | Tender Text en | Product URL DE | 25 | 34 | 0.0000174355 | REHAU Compression sleeve RAUTITAN PX 32 | 4007360361235 | 11600041001 | 1951 | https://oxomi.com/p/3000126/datasheet/-/11600041001 | 0.027828
1078769 | Tender Text en | Product URL DE | 20 | 27.2 | 0.0000087028 | REHAU Compression sleeve RAUTITAN PX 25 | 4007360361228 | 11600031001 | 1950 | https://oxomi.com/p/3000126/datasheet/-/11600031001 | 0.015828
1078771 | Tender Text en | Product URL DE | 15 | 25 | 0.00000516767 | REHAU Compression sleeve RAUTITAN PX 20 | 4007360361211 | 11600021001 | 1949 | https://oxomi.com/p/3000126/datasheet/-/11600021001 | 0.011
1078773 | Tender Text en | Product URL DE | 40 | 45 | 0.0000353695 | REHAU Compr. sleeve RAUTITAN PX stabil 50 | 4062178755416 | 11602061001 | 1954 | https://oxomi.com/p/3000126/datasheet/-/11602061001 | 0.0673
1078775 | Tender Text en | Product URL DE | 40 | 45 | 0.0000353695 | REHAU Compr. sleeve RAUTITAN PX stabil 50 | 4062178755416 | 11602061001 | 1954 | https://oxomi.com/p/3000126/datasheet/-/11602061001 | 0.0673
1078777 | Tender Text en | Product URL DE | 50 | 53 | 0.0000702282 | REHAU Compr. sleeve RAUTITAN PX stabil 63 | 4062178755423 | 11602071001 | 1955 | https://oxomi.com/p/3000126/datasheet/-/11602071001 | 0.1106
1078779 | Tender Text en | Product URL DE | 50 | 53 | 0.0000702282 | REHAU Compr. sleeve RAUTITAN PX stabil 63 | 4062178755423 | 11602071001 | 1955 | https://oxomi.com/p/3000126/datasheet/-/11602071001 | 0.1106
1078781 | Tender Text en | Product URL DE | 40 | 45 | 0.0000353695 | REHAU Compr. sleeve RAUTITAN PX stabil 50 | 4062178755416 | 11602061001 | 1954 | https://oxomi.com/p/3000126/datasheet/-/11602061001 | 0.0673
1078783 | Tender Text en | Product URL DE | 32 | 37.8 | 0.0000303041 | REHAU Compression sleeve RAUTITAN PX 40 | 4007360361242 | 11600051001 | 1952 | https://oxomi.com/p/3000126/datasheet/-/11600051001 | 0.03861
1078785 | Tender Text en | Product URL DE | 50 | 53 | 0.0000702282 | REHAU Compr. sleeve RAUTITAN PX stabil 63 | 4062178755423 | 11602071001 | 1955 | https://oxomi.com/p/3000126/datasheet/-/11602071001 | 0.1106
1078787 | Tender Text en | Product URL DE | 40 | 45 | 0.0000353695 | REHAU Compr. sleeve RAUTITAN PX stabil 50 | 4062178755416 | 11602061001 | 1954 | https://oxomi.com/p/3000126/datasheet/-/11602061001 | 0.0673
1078789 | Tender Text en | Product URL DE | 40 | 45 | 0.0000353695 | REHAU Compr. sleeve RAUTITAN PX stabil 50 | 4062178755416 | 11602061001 | 1954 | https://oxomi.com/p/3000126/datasheet/-/11602061001 | 0.0673
1078791 | Tender Text en | Product URL DE | 25 | 34 | 0.0000174355 | REHAU Compression sleeve RAUTITAN PX 32 | 4007360361235 | 11600041001 | 1951 | https://oxomi.com/p/3000126/datasheet/-/11600041001 | 0.027828
1078793 | Tender Text en | Product URL DE | 50 | 53 | 0.0000702282 | REHAU Compr. sleeve RAUTITAN PX stabil 63 | 4062178755423 | 11602071001 | 1955 | https://oxomi.com/p/3000126/datasheet/-/11602071001 | 0.1106
1078795 | Tender Text en | Product URL DE | 32 | 37.8 | 0.0000303041 | REHAU Compression sleeve RAUTITAN PX 40 | 4007360361242 | 11600051001 | 1952 | https://oxomi.com/p/3000126/datasheet/-/11600051001 | 0.03861
1078797 | Tender Text en | Product URL DE | 40 | 45 | 0.0000353695 | REHAU Compr. sleeve RAUTITAN PX stabil 50 | 4062178755416 | 11602061001 | 1954 | https://oxomi.com/p/3000126/datasheet/-/11602061001 | 0.0673
1078799 | Tender Text en | Product URL DE | 20 | 27.2 | 0.0000087028 | REHAU Compression sleeve RAUTITAN PX 25 | 4007360361228 | 11600031001 | 1950 | https://oxomi.com/p/3000126/datasheet/-/11600031001 | 0.015828
1078801 | Tender Text en | Product URL DE | 50 | 53 | 0.0000702282 | REHAU Compr. sleeve RAUTITAN PX stabil 63 | 4062178755423 | 11602071001 | 1955 | https://oxomi.com/p/3000126/datasheet/-/11602071001 | 0.1106
1078803 | Tender Text en | Product URL DE | 25 | 34 | 0.0000174355 | REHAU Compression sleeve RAUTITAN PX 32 | 4007360361235 | 11600041001 | 1951 | https://oxomi.com/p/3000126/datasheet/-/11600041001 | 0.027828
1078805 | Tender Text en | Product URL DE | 50 | 53 | 0.0000702282 | REHAU Compr. sleeve RAUTITAN PX stabil 63 | 4062178755423 | 11602071001 | 1955 | https://oxomi.com/p/3000126/datasheet/-/11602071001 | 0.1106
1078807 | Tender Text en | Product URL DE | 20 | 27.2 | 0.0000087028 | REHAU Compression sleeve RAUTITAN PX 25 | 4007360361228 | 11600031001 | 1950 | https://oxomi.com/p/3000126/datasheet/-/11600031001 | 0.015828
1078809 | Tender Text en | Product URL DE | 40 | 45 | 0.0000353695 | REHAU Compr. sleeve RAUTITAN PX stabil 50 | 4062178755416 | 11602061001 | 1954 | https://oxomi.com/p/3000126/datasheet/-/11602061001 | 0.0673
1078811 | Tender Text en | Product URL DE | 20 | 27.2 | 0.0000087028 | REHAU Compression sleeve RAUTITAN PX 25 | 4007360361228 | 11600031001 | 1950 | https://oxomi.com/p/3000126/datasheet/-/11600031001 | 0.015828
1078813 | Tender Text en | Product URL DE | 40 | 45 | 0.0000353695 | REHAU Compr. sleeve RAUTITAN PX stabil 50 | 4062178755416 | 11602061001 | 1954 | https://oxomi.com/p/3000126/datasheet/-/11602061001 | 0.0673
1078815 | Tender Text en | Product URL DE | 50 | 53 | 0.0000702282 | REHAU Compr. sleeve RAUTITAN PX stabil 63 | 4062178755423 | 11602071001 | 1955 | https://oxomi.com/p/3000126/datasheet/-/11602071001 | 0.1106
1078817 | Tender Text en | Product URL DE | 40 | 45 | 0.0000353695 | REHAU Compr. sleeve RAUTITAN PX stabil 50 | 4062178755416 | 11602061001 | 1954 | https://oxomi.com/p/3000126/datasheet/-/11602061001 | 0.0673
1078819 | Tender Text en | Product URL DE | 50 | 53 | 0.0000702282 | REHAU Compr. sleeve RAUTITAN PX stabil 63 | 4062178755423 | 11602071001 | 1955 | https://oxomi.com/p/3000126/datasheet/-/11602071001 | 0.1106
1078821 | Tender Text en | Product URL DE | 40 | 45 | 0.0000353695 | REHAU Compr. sleeve RAUTITAN PX stabil 50 | 4062178755416 | 11602061001 | 1954 | https://oxomi.com/p/3000126/datasheet/-/11602061001 | 0.0673
1078823 | Tender Text en | Product URL DE | 50 | 53 | 0.0000702282 | REHAU Compr. sleeve RAUTITAN PX stabil 63 | 4062178755423 | 11602071001 | 1955 | https://oxomi.com/p/3000126/datasheet/-/11602071001 | 0.1106
1078825 | Tender Text en | Product URL DE | 40 | 45 | 0.0000353695 | REHAU Compr. sleeve RAUTITAN PX stabil 50 | 4062178755416 | 11602061001 | 1954 | https://oxomi.com/p/3000126/datasheet/-/11602061001 | 0.0673
1078827 | Tender Text en | Product URL DE | 50 | 53 | 0.0000702282 | REHAU Compr. sleeve RAUTITAN PX stabil 63 | 4062178755423 | 11602071001 | 1955 | https://oxomi.com/p/3000126/datasheet/-/11602071001 | 0.1106
1078829 | Tender Text en | Product URL DE | 50 | 53 | 0.0000702282 | REHAU Compr. sleeve RAUTITAN PX stabil 63 | 4062178755423 | 11602071001 | 1955 | https://oxomi.com/p/3000126/datasheet/-/11602071001 | 0.1106
1078831 | Tender Text en | Product URL DE | 32 | 37.8 | 0.0000303041 | REHAU Compression sleeve RAUTITAN PX 40 | 4007360361242 | 11600051001 | 1952 | https://oxomi.com/p/3000126/datasheet/-/11600051001 | 0.03861
1078833 | Tender Text en | Product URL DE | 20 | 27.2 | 0.0000087028 | REHAU Compression sleeve RAUTITAN PX 25 | 4007360361228 | 11600031001 | 1950 | https://oxomi.com/p/3000126/datasheet/-/11600031001 | 0.015828
1078835 | Tender Text en | Product URL DE | 25 | 34 | 0.0000174355 | REHAU Compression sleeve RAUTITAN PX 32 | 4007360361235 | 11600041001 | 1951 | https://oxomi.com/p/3000126/datasheet/-/11600041001 | 0.027828
1078837 | Tender Text en | Product URL DE | 15 | 25 | 0.00000516767 | REHAU Compression sleeve RAUTITAN PX 20 | 4007360361211 | 11600021001 | 1949 | https://oxomi.com/p/3000126/datasheet/-/11600021001 | 0.011
1078843 | Tender Text en | Product URL DE | 20 | 27.2 | 0.0000087028 | REHAU Compression sleeve RAUTITAN PX 25 | 4007360361228 | 11600031001 | 1950 | https://oxomi.com/p/3000126/datasheet/-/11600031001 | 0.015828
1078845 | Tender Text en | Product URL DE | 25 | 34 | 0.0000174355 | REHAU Compression sleeve RAUTITAN PX 32 | 4007360361235 | 11600041001 | 1951 | https://oxomi.com/p/3000126/datasheet/-/11600041001 | 0.027828
1078851 | Tender Text en | Product URL DE | 25 | 34 | 0.0000174355 | REHAU Compression sleeve RAUTITAN PX 32 | 4007360361235 | 11600041001 | 1951 | https://oxomi.com/p/3000126/datasheet/-/11600041001 | 0.027828
1078867 | Tender Text en | Product URL DE | 20 | 27.2 | 0.0000087028 | REHAU Compression sleeve RAUTITAN PX 25 | 4007360361228 | 11600031001 | 1950 | https://oxomi.com/p/3000126/datasheet/-/11600031001 | 0.015828
1078869 | Tender Text en | Product URL DE | 25 | 34 | 0.0000174355 | REHAU Compression sleeve RAUTITAN PX 32 | 4007360361235 | 11600041001 | 1951 | https://oxomi.com/p/3000126/datasheet/-/11600041001 | 0.027828
1078871 | Tender Text en | Product URL DE | 20 | 27.2 | 0.0000087028 | REHAU Compression sleeve RAUTITAN PX 25 | 4007360361228 | 11600031001 | 1950 | https://oxomi.com/p/3000126/datasheet/-/11600031001 | 0.015828
1078873 | Tender Text en | Product URL DE | 25 | 34 | 0.0000174355 | REHAU Compression sleeve RAUTITAN PX 32 | 4007360361235 | 11600041001 | 1951 | https://oxomi.com/p/3000126/datasheet/-/11600041001 | 0.027828
