Properties of the parts of a building model (IFC4), part 5 of 10

# IfcPipeFitting: RAUTITAN_Transition_LX:RTI LX/PX Tr DN (2)
Type - Mechanical - Loss Method: K Coefficient; K Coefficient: 0.6; K Coefficient Table: Reducer/Coupling/Union/Increaser
Type - Pset_ManufacturerTypeInformation - Manufacturer: REHAU
Classification: D2090800 (Uniformat)
Pset_EnvironmentalImpactIndicators - Reference: RAUTITAN_Transition_LX:RTI LX/PX Tr DN; sets with these values: 2
Other - IsCustom: yes; Family: RAUTITAN_Transition_LX; Sleeve DN1: Sleeve : PX 7,4; Family and Type: RAUTITAN_Transition_LX: RTI LX/PX Tr DN; Type: RTI LX/PX Tr DN; Type Id: 797025
Constraints - Elevation from Level: 0 mm; Level: REHAU Starting view
Data - PID Check: 0 mm
Dimensions - Area: 0.00465431 m2; Volume: 0.0000321717 m3
Graphics - Use Annotation Scale: no
Identity Data - ETIM Class: EC003024; ETIM Group: EG015540; ETIM Name: Fitting with 2 connections; PID: -; Tender text: -
Mechanical - System Classification: Undefined
Phasing - Phase Created: New Construction
Insulation - Insulation Thickness: 0 mm
Name (RAUTITAN_Transition_LX:RTI LX/PX Tr DN:...) | Sleeve DN2 | Di1 (mm) | DN1 (mm) = Maximum Size (mm) | DN2 (mm) = Minimum Size (mm) | Size = Overall Size | Description long | GTIN | Product Group | Product URL | Sorting | Weight
1078151 | Sleeve : PX 7,4 | 12.5 | 15 | 12 | 15 mmø-12 mmø | REHAU Coupling RAUTITAN LX +G 20 - 16 | 4007360543082 | 1627 | https://oxomi.com/p/3000126/datasheet/-/13129761001 | 1633 | 0.048
1451456 | Sleeve : LX 7,4 | 9.9 | 12 | 10 | 12 mmø-10 mmø | REHAU Coupling SDR 7.4 LX 16 - 12 | - | - | https://oxomi.com/p/3000126/datasheet/-/11682021001 | 0 | 0

# IfcPipeFitting: RAUTITAN_Transition_PX:RTI PX Tr DN (5)
In: REHAU Starting view
Type - Material: RAUTITAN PX
Type - Other - Category: Pipe Fittings; Family Name: RAUTITAN_Transition_PX; T1: RTI Transition PX; T2: RTI Transition PX MES
Type - Constraints - Default Elevation: 0 mm
Type - Data - Language: Description en; Language Tender Text: Tender Text en; Region Check: Check DE; Region PID: PID DE; Region URL: Product URL DE; T3: Sleeve DN
Type - Identity Data - Assembly Code: D2090800; Classification Number: 23.60.30.11.14; Manufacturer: REHAU; Model: RAUTITAN; REHAU Info: 14.02.2024-420668-420668; Type Name: RTI PX Tr DN
Type - Mechanical - Loss Method: K Coefficient; K Coefficient: 0.6; K Coefficient Table: Reducer/Coupling/Union/Increaser
Type - Pset_ManufacturerTypeInformation - Manufacturer: REHAU
Classification: D2090800 (Uniformat)
Pset_EnvironmentalImpactIndicators - Reference: RAUTITAN_Transition_PX:RTI PX Tr DN; sets with these values: 2
Other - IsCustom: no; Family: RAUTITAN_Transition_PX; Family and Type: RAUTITAN_Transition_PX: RTI PX Tr DN; Type: RTI PX Tr DN; Type Id: 799529
Constraints - Elevation from Level: 0 mm; Level: REHAU Starting view
Data - PID Check: 1 mm
Dimensions - Area: 0.00465431 m2
Graphics - Use Annotation Scale: no
Identity Data - Sorting: 0; ETIM Class: EC003024; ETIM Group: EG015540; ETIM Name: Fitting with 2 connections; Tender text: -
Mechanical - System Classification: Undefined
Phasing - Phase Created: New Construction
Insulation - Insulation Thickness: 0 mm
Name (RAUTITAN_Transition_PX:RTI PX Tr DN:...) | Di1 (mm) | DN1 (mm) = Maximum Size (mm) | DN2 (mm) = Minimum Size (mm) | Size = Overall Size | Volume (m3) | Description long | GTIN | PID | Product Group | Product URL | Weight
1078312 | 22 | 32 | 25 | 32 mmø-25 mmø | 0.0000481828 | REHAU Coupling RAUTITAN PX 40 - 32 | 4007360376901 | 11600471001 | 1618 | https://oxomi.com/p/3000126/datasheet/-/11600471001 | 0.0609
1078318 | 18.1 | 25 | 20 | 25 mmø-20 mmø | 0.000025578 | REHAU Coupling RAUTITAN PX 32 - 25 | 4007360376895 | 11600441001 | 1617 | https://oxomi.com/p/3000126/datasheet/-/11600441001 | 0.0336
1078320 | 13.5 | 20 | 15 | 20 mmø-15 mmø | 0.0000144369 | REHAU Coupling RAUTITAN PX 25 - 20 | 4007360375805 | 11600431001 | 1616 | https://oxomi.com/p/3000126/datasheet/-/11600431001 | 0.0188
1078322 | 11.2 | 15 | 12 | 15 mmø-12 mmø | 0.00000855168 | REHAU Coupling RAUTITAN PX 20 - 16 | 4007360375799 | 11600411001 | 1614 | https://oxomi.com/p/3000126/datasheet/-/11600411001 | 0.0111
1078351 | 13.5 | 20 | 12 | 20 mmø-12 mmø | 0.0000123823 | REHAU Coupling RAUTITAN PX 25 - 16 | 4007360376888 | 11600421001 | 1615 | https://oxomi.com/p/3000126/datasheet/-/11600421001 | 0.0165

# IfcPipeFitting: RAUTITAN_Transition_RX+ stabil:RTI RX+ stabil Tr DN (3)
In: REHAU Starting view
Type - Material: RAUTITAN RX+
Type - Other - Category: Pipe Fittings; Family Name: RAUTITAN_Transition_RX+ stabil; T1: RTI Transition RX+ stabil; T2: RTI Transition RX+ stabil MES
Type - Constraints - Default Elevation: 0 mm
Type - Data - Language: Description en; Language Tender Text: Tender Text en; Region Check: Check DE; Region PID: PID DE; Region URL: Product URL DE; T3: Sleeve DN
Type - Identity Data - Assembly Code: D2090800; Classification Number: 23.60.30.11.14; Manufacturer: REHAU; Model: RAUTITAN; REHAU Info: 14.02.2024-420668-420668; Type Name: RTI RX+ stabil Tr DN
Type - Mechanical - Loss Method: K Coefficient; K Coefficient: 0.6; K Coefficient Table: Reducer/Coupling/Union/Increaser
Type - Pset_ManufacturerTypeInformation - Manufacturer: REHAU
Classification: D2090800 (Uniformat)
Pset_EnvironmentalImpactIndicators - Reference: RAUTITAN_Transition_RX+ stabil:RTI RX+ stabil Tr DN; sets with these values: 2
Other - IsCustom: no; Family: RAUTITAN_Transition_RX+ stabil; Family and Type: RAUTITAN_Transition_RX+ stabil: RTI RX+ stabil Tr DN; Type: RTI RX+ stabil Tr DN; Type Id: 802013
Constraints - Elevation from Level: 0 mm; Level: REHAU Starting view
Data - PID Check: 1 mm
Dimensions - Area: 0.00465431 m2
Graphics - Use Annotation Scale: no
Identity Data - Sorting: 0; ETIM Class: EC003024; ETIM Class code: EC003025; ETIM Group: EG015540; ETIM Name: Fitting with 2 connections; Tender text: -
Mechanical - System Classification: Undefined
Phasing - Phase Created: New Construction
Insulation - Insulation Thickness: 0 mm
Name (RAUTITAN_Transition_RX+ stabil:RTI RX+ stabil Tr DN:...) | Di1 (mm) | DN1 (mm) = Maximum Size (mm) | DN2 (mm) = Minimum Size (mm) | Size = Overall Size | Volume (m3) | Description long | GTIN | PID | Product Group | Product URL | Weight
1078314 | 33.5 | 40 | 32 | 40 mmø-32 mmø | 0.0000674503 | REHAU Coupling RAUTITAN RX+ stabil 50 - 40 | 4062178755560 | 14600541001 | 1638 | https://oxomi.com/p/3000126/datasheet/-/14600541001 | 0.504
1078316 | 45.5 | 50 | 40 | 50 mmø-40 mmø | 0.000106861 | REHAU Coupling RAUTITAN RX+ stabil 63 - 50 | 4062178755577 | 14600551001 | 1639 | https://oxomi.com/p/3000126/datasheet/-/14600551001 | 0.867
1078349 | 33.5 | 40 | 25 | 40 mmø-25 mmø | 0.0000522192 | REHAU Coupling RAUTITAN RX+ stabil 50 - 32 | 4062178755553 | 14600531001 | 1637 | https://oxomi.com/p/3000126/datasheet/-/14600531001 | 0.41

# IfcPipeFitting: RAUTITAN_Transition_RX+:RTI RX+ Tr DN (6)
In: REHAU Starting view
Type - Material: RAUTITAN RX+
Type - Other - Category: Pipe Fittings; Sleeve LX 7.4: Sleeve : LX 7,4; Sleeve PX 7.4: Sleeve : PX 7,4; Family Name: RAUTITAN_Transition_RX+; Max Sleeve: 32 mm; T1: RTI Transition RX; T2: RTI Transition RX MES
Type - Constraints - Default Elevation: 0 mm
Type - Data - Language: Description en; Language Tender Text: Tender Text en; Region Check: Check DE; Region PID: PID DE; Region URL: Product URL DE; T3: Sleeve DN
Type - Identity Data - Assembly Code: D2090800; Classification Number: 23.60.30.11.14; Manufacturer: REHAU; Model: RAUTITAN; REHAU Info: 14.02.2024-420668-420668; Type Name: RTI RX+ Tr DN
Type - Mechanical - Loss Method: K Coefficient; K Coefficient: 0.6; K Coefficient Table: Reducer/Coupling/Union/Increaser
Type - Pset_ManufacturerTypeInformation - Manufacturer: REHAU
Classification: D2090800 (Uniformat)
Pset_EnvironmentalImpactIndicators - Reference: RAUTITAN_Transition_RX+:RTI RX+ Tr DN; sets with these values: 2
Other - IsCustom: no; Family: RAUTITAN_Transition_RX+; Family and Type: RAUTITAN_Transition_RX+: RTI RX+ Tr DN; Type: RTI RX+ Tr DN; Type Id: 804493
Constraints - Elevation from Level: 0 mm; Level: REHAU Starting view
Data - PID Check: 1 mm
Dimensions - Area: 0.00465431 m2
Graphics - Use Annotation Scale: no
Identity Data - Sorting: 0; ETIM Class: EC003024; ETIM Group: EG015540; ETIM Name: Fitting with 2 connections; Tender text: -
Mechanical - System Classification: Undefined
Phasing - Phase Created: New Construction
Insulation - Insulation Thickness: 0 mm
Name (RAUTITAN_Transition_RX+:RTI RX+ Tr DN:...) | Sleeve DN1 | Sleeve DN2 | Di1 (mm) | DN1 (mm) = Maximum Size (mm) | DN2 (mm) = Minimum Size (mm) | Size = Overall Size | Volume (m3) | Description long | GTIN | PID | Product Group | Product URL | Weight
1078439 | Sleeve : PX 7,4 | Sleeve : PX 7,4 | 23.5 | 32 | 20 | 32 mmø-20 mmø | 0.0000324167 | REHAU Coupling RAUTITAN RX+ 40 - 25 | 4061264398094 | 14563951001 | 1589 | https://oxomi.com/p/3000126/datasheet/-/14563951001 | 0.247
1078441 | Sleeve : LX 7,4 | Sleeve : PX 7,4 | 30.5 | 40 | 32 | 40 mmø-32 mmø | 0.0000662048 | REHAU Coupling RAUTITAN RX+ 50 - 40 | 4061264397196 | 14563051001 | 1591 | https://oxomi.com/p/3000126/datasheet/-/14563051001 | 0.487
1078443 | Sleeve : LX 7,4 | Sleeve : LX 7,4 | 39.5 | 50 | 40 | 50 mmø-40 mmø | 0.000103446 | REHAU Coupling RAUTITAN RX+ 63 - 50 | 4061264397202 | 14563061001 | 1592 | https://oxomi.com/p/3000126/datasheet/-/14563061001 | 0.813
1078445 | Sleeve : PX 7,4 | Sleeve : PX 7,4 | 20 | 25 | 20 | 25 mmø-20 mmø | 0.0000220189 | REHAU Coupling RAUTITAN RX+ 32 - 25 | 4061264398629 | 14564481001 | 1586 | https://oxomi.com/p/3000126/datasheet/-/14564481001 | 0.165
1078447 | Sleeve : PX 7,4 | Sleeve : PX 7,4 | 15.2 | 20 | 15 | 20 mmø-15 mmø | 0.0000122248 | REHAU Coupling RAUTITAN RX+ 25 - 20 | 4061264398605 | 14564461001 | 1585 | https://oxomi.com/p/3000126/datasheet/-/14564461001 | 0.106
1078458 | Sleeve : LX 7,4 | Sleeve : PX 7,4 | 30.5 | 40 | 25 | 40 mmø-25 mmø | 0.0000511531 | REHAU Coupling RAUTITAN RX+ 50 - 32 | 4061264397189 | 14563041001 | 1590 | https://oxomi.com/p/3000126/datasheet/-/14563041001 | 0.387

# IfcPipeFitting: RAUTITAN_Union_LX:RTI LX U DN (6)
In: REHAU Starting view
Type - Material: Brass
Type - Other - Category: Pipe Fittings; Family Name: RAUTITAN_Union_LX; Max sleeve: 32 mm; Min sleeve: 12 mm; Sleeve LX 7.4: Sleeve : LX 7,4; Sleeve PX 7.4: Sleeve : LX 7,4; T1: RTI Union LX; T2: RTI Union LX MES
Type - Constraints - Default Elevation: 0 mm
Type - Data - Language: Description en; Language Tender Text: Tender Text en; Region Check: Check DE; Region PID: PID DE; Region URL: Product URL DE; T3: Sleeve DN
Type - Identity Data - Assembly Code: D2090800; Classification Number: 23.60.30.11.14; Manufacturer: REHAU; Model: RAUTITAN; REHAU Info: 14.02.2024-420668-420668; Type Name: RTI LX U DN
Type - Mechanical - Loss Method: K Coefficient; K Coefficient: 0.6; K Coefficient Table: Reducer/Coupling/Union/Increaser
Type - Pset_ManufacturerTypeInformation - Manufacturer: REHAU
Classification: D2090800 (Uniformat)
Pset_EnvironmentalImpactIndicators - Reference: RAUTITAN_Union_LX:RTI LX U DN; sets with these values: 2
Other - Sleeve DN1: Sleeve : LX 7,4; Sleeve DN2: Sleeve : LX 7,4; IsCustom: no; Family: RAUTITAN_Union_LX; Family and Type: RAUTITAN_Union_LX: RTI LX U DN; Type: RTI LX U DN; Type Id: 808138
Constraints - Elevation from Level: 0 mm; Level: REHAU Starting view
Data - PID Check: 1 mm
Dimensions - Area: 0.00465431 m2
Graphics - Use Annotation Scale: no
Identity Data - Sorting: 0; ETIM Class: EC003024; ETIM Group: EG015540; ETIM Name: Fitting with 2 connections; Tender text: -
Mechanical - System Classification: Undefined
Phasing - Phase Created: New Construction
Insulation - Insulation Thickness: 0 mm
Name (RAUTITAN_Union_LX:RTI LX U DN:...) | Di1 (mm) | DN1 (mm) = DN2 (mm) = Maximum Size (mm) = Minimum Size (mm) | Size = Overall Size | Volume (m3) | Description long | GTIN | PID | Product Group | Product URL | Weight
948555 | 12.5 | 15 | 15 mmø-15 mmø | 0.00000792358 | REHAU Coupling RAUTITAN LX +G 20 - 20 | 4007360543020 | 13129701001 | 1621 | https://oxomi.com/p/3000126/datasheet/-/13129701001 | 0.058
948622 | 15.2 | 20 | 20 mmø-20 mmø | 0.0000145261 | REHAU Coupling RAUTITAN LX +G 25 - 25 | 4007360543037 | 13129711001 | 1622 | https://oxomi.com/p/3000126/datasheet/-/13129711001 | 0.112
948635 | 20 | 25 | 25 mmø-25 mmø | 0.0000236626 | REHAU Coupling RAUTITAN LX +G 32 - 32 | 4007360543051 | 13129731001 | 1624 | https://oxomi.com/p/3000126/datasheet/-/13129731001 | 0.184
948740 | 23 | 32 | 32 mmø-32 mmø | 0.0000505311 | REHAU Coupling RAUTITAN LX +G 40 - 40 | 4007360543044 | 13129721001 | 1623 | https://oxomi.com/p/3000126/datasheet/-/13129721001 | 0.38
948753 | 30 | 40 | 40 mmø-40 mmø | 0.0000760356 | REHAU Coupling SDR 7.4 LX 50 - 50 | 4007360459109 | 11680201001 | 1604 | https://oxomi.com/p/3000126/datasheet/-/11680201001 | 0.59
948766 | 39 | 50 | 50 mmø-50 mmø | 0.000128925 | REHAU Coupling SDR 7.4 LX 63 - 63 | 4007360459123 | 11680221001 | 1606 | https://oxomi.com/p/3000126/datasheet/-/11680221001 | 0.98

# IfcPipeFitting: RAUTITAN_Union_LX:RTI LX U DN (2)
In: REHAU Starting view
Type - Material: Brass, Error
Type - Other - Category: Pipe Fittings; Family Name: RAUTITAN_Union_LX; Max sleeve: 32 mm; Min sleeve: 12 mm; Sleeve LX 7.4: Sleeve : LX 7,4; Sleeve PX 7.4: Sleeve : LX 7,4; T1: RTI Union LX; T2: RTI Union LX MES
Type - Constraints - Default Elevation: 0 mm
Type - Data - Language: Description en; Language Tender Text: Tender Text en; Region Check: Check DE; Region PID: PID DE; Region URL: Product URL DE; T3: Sleeve DN
Type - Identity Data - Assembly Code: D2090800; Classification Number: 23.60.30.11.14; Manufacturer: REHAU; Model: RAUTITAN; REHAU Info: 14.02.2024-420668-420668; Type Name: RTI LX U DN
Type - Mechanical - Loss Method: K Coefficient; K Coefficient: 0.6; K Coefficient Table: Reducer/Coupling/Union/Increaser
Type - Pset_ManufacturerTypeInformation - Manufacturer: REHAU
Classification: D2090800 (Uniformat)
Pset_EnvironmentalImpactIndicators - Reference: RAUTITAN_Union_LX:RTI LX U DN; sets with these values: 2
Other - IsCustom: yes; Sleeve DN1: Sleeve : LX 7,4; Sleeve DN2: Sleeve : LX 7,4; Family: RAUTITAN_Union_LX; Family and Type: RAUTITAN_Union_LX: RTI LX U DN; Type: RTI LX U DN; Type Id: 808138
Constraints - Elevation from Level: 0 mm; Level: REHAU Starting view
Data - PID Check: 0 mm
Dimensions - Area: 0.00465431 m2; Volume: 0.0000321717 m3
Graphics - Use Annotation Scale: no
Identity Data - Sorting: 0; ETIM Class: EC003024; ETIM Group: EG015540; ETIM Name: Fitting with 2 connections; PID: -; Tender text: -
Mechanical - System Classification: Undefined
Phasing - Phase Created: New Construction
Insulation - Insulation Thickness: 0 mm
Name (RAUTITAN_Union_LX:RTI LX U DN:...) | Di1 (mm) | DN1 (mm) = DN2 (mm) = Maximum Size (mm) = Minimum Size (mm) | Size = Overall Size | Description long | GTIN | Product Group | Product URL | Weight
944500 | 6.6 | 10 | 10 mmø-10 mmø | REHAU Coupling SDR 7.4 LX 12 - 12 | 4007360469009 | 1596 | https://oxomi.com/p/3000126/datasheet/-/11681761001 | 0.023
948439 | 9.9 | 12 | 12 mmø-12 mmø | REHAU Coupling RAUTITAN LX +G 16 - 16 | 4007360543013 | 1620 | https://oxomi.com/p/3000126/datasheet/-/13129691001 | 0.039

# IfcPipeFitting: RAUTITAN_Union_LX:RTI LX/PX U DN (6)
In: REHAU Starting view
Type - Material: Brass
Type - Other - Category: Pipe Fittings; Sleeve LX 7.4: Sleeve : LX 7,4; Family Name: RAUTITAN_Union_LX; Max sleeve: 32 mm; Min sleeve: 12 mm; Sleeve PX 7.4: Sleeve : PX 7,4; T1: RTI Union LX; T2: RTI Union LX MES
Type - Constraints - Default Elevation: 0 mm
Type - Data - Language: Description en; Language Tender Text: Tender Text en; Region Check: Check DE; Region PID: PID DE; Region URL: Product URL DE; T3: Sleeve DN
Type - Identity Data - Assembly Code: D2090800; Classification Number: 23.60.30.11.14; Manufacturer: REHAU; Model: RAUTITAN; REHAU Info: 14.02.2024-420668-420668; Type Name: RTI LX/PX U DN
Type - Mechanical - Loss Method: K Coefficient; K Coefficient: 0.6; K Coefficient Table: Reducer/Coupling/Union/Increaser
Type - Pset_ManufacturerTypeInformation - Manufacturer: REHAU
Classification: D2090800 (Uniformat)
Pset_EnvironmentalImpactIndicators - Reference: RAUTITAN_Union_LX:RTI LX/PX U DN; sets with these values: 2
Other - IsCustom: no; Family: RAUTITAN_Union_LX; Family and Type: RAUTITAN_Union_LX: RTI LX/PX U DN; Type: RTI LX/PX U DN; Type Id: 808140
Constraints - Elevation from Level: 0 mm; Level: REHAU Starting view
Data - PID Check: 1 mm
Dimensions - Area: 0.00465431 m2
Graphics - Use Annotation Scale: no
Identity Data - Sorting: 0; ETIM Class: EC003024; ETIM Group: EG015540; ETIM Name: Fitting with 2 connections; Tender text: -
Mechanical - System Classification: Undefined
Phasing - Phase Created: New Construction
Insulation - Insulation Thickness: 0 mm
Name (RAUTITAN_Union_LX:RTI LX/PX U DN:...) | Sleeve DN1 = Sleeve DN2 | Di1 (mm) | DN1 (mm) = DN2 (mm) = Maximum Size (mm) = Minimum Size (mm) | Size = Overall Size | Volume (m3) | Description long | GTIN | PID | Product Group | Product URL | Weight
1078137 | Sleeve : PX 7,4 | 12.5 | 15 | 15 mmø-15 mmø | 0.00000792358 | REHAU Coupling RAUTITAN LX +G 20 - 20 | 4007360543020 | 13129701001 | 1621 | https://oxomi.com/p/3000126/datasheet/-/13129701001 | 0.058
1078139 | Sleeve : PX 7,4 | 15.2 | 20 | 20 mmø-20 mmø | 0.0000145261 | REHAU Coupling RAUTITAN LX +G 25 - 25 | 4007360543037 | 13129711001 | 1622 | https://oxomi.com/p/3000126/datasheet/-/13129711001 | 0.112
1078141 | Sleeve : PX 7,4 | 20 | 25 | 25 mmø-25 mmø | 0.0000236626 | REHAU Coupling RAUTITAN LX +G 32 - 32 | 4007360543051 | 13129731001 | 1624 | https://oxomi.com/p/3000126/datasheet/-/13129731001 | 0.184
1078143 | Sleeve : PX 7,4 | 23 | 32 | 32 mmø-32 mmø | 0.0000505311 | REHAU Coupling RAUTITAN LX +G 40 - 40 | 4007360543044 | 13129721001 | 1623 | https://oxomi.com/p/3000126/datasheet/-/13129721001 | 0.38
1079111 | Sleeve : LX 7,4 | 30 | 40 | 40 mmø-40 mmø | 0.0000760356 | REHAU Coupling SDR 7.4 LX 50 - 50 | 4007360459109 | 11680201001 | 1604 | https://oxomi.com/p/3000126/datasheet/-/11680201001 | 0.59
1079124 | Sleeve : LX 7,4 | 39 | 50 | 50 mmø-50 mmø | 0.000128925 | REHAU Coupling SDR 7.4 LX 63 - 63 | 4007360459123 | 11680221001 | 1606 | https://oxomi.com/p/3000126/datasheet/-/11680221001 | 0.98

# IfcPipeFitting: RAUTITAN_Union_LX:RTI LX/PX U DN (2)
In: REHAU Starting view
Type - Material: Brass, Error
Type - Other - Category: Pipe Fittings; Sleeve LX 7.4: Sleeve : LX 7,4; Family Name: RAUTITAN_Union_LX; Max sleeve: 32 mm; Min sleeve: 12 mm; Sleeve PX 7.4: Sleeve : PX 7,4; T1: RTI Union LX; T2: RTI Union LX MES
Type - Constraints - Default Elevation: 0 mm
Type - Data - Language: Description en; Language Tender Text: Tender Text en; Region Check: Check DE; Region PID: PID DE; Region URL: Product URL DE; T3: Sleeve DN
Type - Identity Data - Assembly Code: D2090800; Classification Number: 23.60.30.11.14; Manufacturer: REHAU; Model: RAUTITAN; REHAU Info: 14.02.2024-420668-420668; Type Name: RTI LX/PX U DN
Type - Mechanical - Loss Method: K Coefficient; K Coefficient: 0.6; K Coefficient Table: Reducer/Coupling/Union/Increaser
Type - Pset_ManufacturerTypeInformation - Manufacturer: REHAU
Classification: D2090800 (Uniformat)
Pset_EnvironmentalImpactIndicators - Reference: RAUTITAN_Union_LX:RTI LX/PX U DN; sets with these values: 2
Other - IsCustom: yes; Family: RAUTITAN_Union_LX; Family and Type: RAUTITAN_Union_LX: RTI LX/PX U DN; Type: RTI LX/PX U DN; Type Id: 808140
Constraints - Elevation from Level: 0 mm; Level: REHAU Starting view
Data - PID Check: 0 mm
Dimensions - Area: 0.00465431 m2; Volume: 0.0000321717 m3
Graphics - Use Annotation Scale: no
Identity Data - Sorting: 0; ETIM Class: EC003024; ETIM Group: EG015540; ETIM Name: Fitting with 2 connections; PID: -; Tender text: -
Mechanical - System Classification: Undefined
Phasing - Phase Created: New Construction
Insulation - Insulation Thickness: 0 mm
Name (RAUTITAN_Union_LX:RTI LX/PX U DN:...) | Sleeve DN1 = Sleeve DN2 | Di1 (mm) | DN1 (mm) = DN2 (mm) = Maximum Size (mm) = Minimum Size (mm) | Size = Overall Size | Description long | GTIN | Product Group | Product URL | Weight
1078135 | Sleeve : PX 7,4 | 9.9 | 12 | 12 mmø-12 mmø | REHAU Coupling RAUTITAN LX +G 16 - 16 | 4007360543013 | 1620 | https://oxomi.com/p/3000126/datasheet/-/13129691001 | 0.039
1440940 | Sleeve : LX 7,4 | 6.6 | 10 | 10 mmø-10 mmø | REHAU Coupling SDR 7.4 LX 12 - 12 | 4007360469009 | 1596 | https://oxomi.com/p/3000126/datasheet/-/11681761001 | 0.023

# IfcPipeFitting: RAUTITAN_Union_PX:RTI PX U DN (5)
In: REHAU Starting view
Type - Material: RAUTITAN PX
Type - Other - Category: Pipe Fittings; Family Name: RAUTITAN_Union_PX; T1: RTI Union PX; T2: RTI Union PX MES
Type - Constraints - Default Elevation: 0 mm
Type - Data - Language: Description en; Language Tender Text: Tender Text en; Region Check: Check DE; Region PID: PID DE; Region URL: Product URL DE; T3: Sleeve DN
Type - Identity Data - Assembly Code: D2090800; Classification Number: 23.60.30.11.14; Manufacturer: REHAU; Model: RAUTITAN; REHAU Info: 14.02.2024-420668-420668; Type Name: RTI PX U DN
Type - Mechanical - Loss Method: K Coefficient; K Coefficient: 0.6; K Coefficient Table: Reducer/Coupling/Union/Increaser
Type - Pset_ManufacturerTypeInformation - Manufacturer: REHAU
Classification: D2090800 (Uniformat)
Pset_EnvironmentalImpactIndicators - Reference: RAUTITAN_Union_PX:RTI PX U DN; sets with these values: 2
Other - IsCustom: no; Family: RAUTITAN_Union_PX; Family and Type: RAUTITAN_Union_PX: RTI PX U DN; Type: RTI PX U DN; Type Id: 810584
Constraints - Elevation from Level: 0 mm; Level: REHAU Starting view
Data - PID Check: 1 mm
Dimensions - Area: 0.00465431 m2
Graphics - Use Annotation Scale: no
Identity Data - Sorting: 0; ETIM Class: EC003024; ETIM Group: EG015540; ETIM Name: Fitting with 2 connections; Tender text: -
Mechanical - System Classification: Undefined
Phasing - Phase Created: New Construction
Insulation - Insulation Thickness: 0 mm
Name (RAUTITAN_Union_PX:RTI PX U DN:...) | Di1 (mm) | DN1 (mm) = Maximum Size (mm) = Minimum Size (mm) | Size = Overall Size | Volume (m3) | Description long | GTIN | PID | Product Group | Product URL | Weight
1078297 | 9 | 12 | 12 mmø-12 mmø | 0.00000589389 | REHAU Coupling RAUTITAN PX 16 - 16 | 4007360366407 | 11600111001 | 1609 | https://oxomi.com/p/3000126/datasheet/-/11600111001 | 0.0076
1078299 | 11.2 | 15 | 15 mmø-15 mmø | 0.00000980928 | REHAU Coupling RAUTITAN PX 20 - 20 | 4007360366414 | 11600121001 | 1610 | https://oxomi.com/p/3000126/datasheet/-/11600121001 | 0.0127
1078301 | 13.5 | 20 | 20 mmø-20 mmø | 0.0000163458 | REHAU Coupling RAUTITAN PX 25 - 25 | 4007360366421 | 11600131001 | 1611 | https://oxomi.com/p/3000126/datasheet/-/11600131001 | 0.0207
1078303 | 18.1 | 25 | 25 mmø-25 mmø | 0.0000298366 | REHAU Coupling RAUTITAN PX 32 - 32 | 4007360366438 | 11600141001 | 1612 | https://oxomi.com/p/3000126/datasheet/-/11600141001 | 0.0377
1078305 | 22 | 32 | 32 mmø-32 mmø | 0.0000553803 | REHAU Coupling RAUTITAN PX 40 - 40 | 4007360366445 | 11600151001 | 1613 | https://oxomi.com/p/3000126/datasheet/-/11600151001 | 0.0682

# IfcPipeFitting: RAUTITAN_Union_RX+ stabil:RTI RX+ stabil U DN (2)
In: REHAU Starting view
Type - Material: RAUTITAN RX+
Type - Other - Category: Pipe Fittings; Family Name: RAUTITAN_Union_RX+ stabil; T1: RTI Union RX+ stabil; T2: RTI Union RX+ stabil MES
Type - Constraints - Default Elevation: 0 mm
Type - Data - Language: Description en; Language Tender Text: Tender Text en; Region Check: Check DE; Region PID: PID DE; Region URL: Product URL DE; T3: Sleeve DN
Type - Identity Data - Assembly Code: D2090800; Classification Number: 23.60.30.11.14; Manufacturer: REHAU; Model: RAUTITAN; REHAU Info: 14.02.2024-420668-420668; Type Name: RTI RX+ stabil U DN
Type - Mechanical - Loss Method: K Coefficient; K Coefficient: 0.6; K Coefficient Table: Reducer/Coupling/Union/Increaser
Type - Pset_ManufacturerTypeInformation - Manufacturer: REHAU
Classification: D2090800 (Uniformat)
Pset_EnvironmentalImpactIndicators - Reference: RAUTITAN_Union_RX+ stabil:RTI RX+ stabil U DN; sets with these values: 2
Other - IsCustom: no; Family: RAUTITAN_Union_RX+ stabil; Family and Type: RAUTITAN_Union_RX+ stabil: RTI RX+ stabil U DN; Type: RTI RX+ stabil U DN; Type Id: 813026
Constraints - Elevation from Level: 0 mm; Level: REHAU Starting view
Data - PID Check: 1 mm
Dimensions - Area: 0.00465431 m2
Graphics - Use Annotation Scale: no
Identity Data - Sorting: 0; ETIM Class: EC003024; ETIM Group: EG015540; ETIM Name: Fitting with 2 connections; Tender text: -
Mechanical - System Classification: Undefined
Phasing - Phase Created: New Construction
Insulation - Insulation Thickness: 0 mm
Name (RAUTITAN_Union_RX+ stabil:RTI RX+ stabil U DN:...) | Di1 (mm) | DN1 (mm) = Maximum Size (mm) = Minimum Size (mm) | Size = Overall Size | Volume (m3) | Description long | GTIN | PID | Product Group | Product URL | Weight
1078307 | 33.5 | 40 | 40 mmø-40 mmø | 0.0000774077 | REHAU Coupling RAUTITAN RX+ stabil 50 - 50 | 4062178676094 | 14600511001 | 1635 | https://oxomi.com/p/3000126/datasheet/-/14600511001 | 0.649
1078309 | 45.5 | 50 | 50 mmø-50 mmø | 0.000130078 | REHAU Coupling RAUTITAN RX+ stabil 63 - 63 | 4062178676100 | 14600521001 | 1636 | https://oxomi.com/p/3000126/datasheet/-/14600521001 | 1.07

# IfcPipeFitting: RAUTITAN_Union_RX+:RTI RX+ U DN (5)
In: REHAU Starting view
Type - Material: RAUTITAN RX+
Type - Other - Category: Pipe Fittings; Family Name: RAUTITAN_Union_RX+; Max Sleeve Size: 32 mm; T1: RTI Union RX; T2: RTI Union RX MES
Type - Constraints - Default Elevation: 0 mm
Type - Data - Language: Description en; Language Tender Text: Tender Text en; Region Check: Check DE; Region PID: PID DE; Region URL: Product URL DE; T3: Sleeve DN
Type - Identity Data - Assembly Code: D2090800; Classification Number: 23.60.30.11.14; Manufacturer: REHAU; Model: RAUTITAN; REHAU Info: 14.02.2024-420668-420668; Type Name: RTI RX+ U DN
Type - Mechanical - Loss Method: K Coefficient; K Coefficient: 0.6; K Coefficient Table: Reducer/Coupling/Union/Increaser
Type - Pset_ManufacturerTypeInformation - Manufacturer: REHAU
Classification: D2090800 (Uniformat)
Pset_EnvironmentalImpactIndicators - Reference: RAUTITAN_Union_RX+:RTI RX+ U DN; sets with these values: 2
Other - IsCustom: no; Family: RAUTITAN_Union_RX+; Family and Type: RAUTITAN_Union_RX+: RTI RX+ U DN; Sleeve LX 7,4: Sleeve : LX 7,4; Sleeve PX 7,4: Sleeve : PX 7,4; Type: RTI RX+ U DN; Type Id: 815466
Constraints - Elevation from Level: 0 mm; Level: REHAU Starting view
Data - PID Check: 1 mm
Dimensions - Area: 0.00465431 m2
Graphics - Use Annotation Scale: no
Identity Data - Sorting: 0; ETIM Class: EC003024; ETIM Group: EG015540; ETIM Name: Fitting with 2 connections; Tender text: -
Mechanical - System Classification: Undefined
Phasing - Phase Created: New Construction
Insulation - Insulation Thickness: 0 mm
Name (RAUTITAN_Union_RX+:RTI RX+ U DN:...) | Sleeve DN1 | Di1 (mm) | DN1 (mm) = Maximum Size (mm) = Minimum Size (mm) | Size = Overall Size | Volume (m3) | Description long | GTIN | PID | Product Group | Product URL | Weight
1078428 | Sleeve : PX 7,4 | 12.5 | 15 | 15 mmø-15 mmø | 0.00000792358 | REHAU Coupling RAUTITAN RX+ 20 - 20 | 4061264398544 | 14564401001 | 1582 | https://oxomi.com/p/3000126/datasheet/-/14564401001 | 0.065
1078430 | Sleeve : PX 7,4 | 15.2 | 20 | 20 mmø-20 mmø | 0.0000145261 | REHAU Coupling RAUTITAN RX+ 25 - 25 | 4061264398551 | 14564411001 | 1583 | https://oxomi.com/p/3000126/datasheet/-/14564411001 | 0.117
1078432 | Sleeve : PX 7,4 | 20 | 25 | 25 mmø-25 mmø | 0.0000241735 | REHAU Coupling RAUTITAN RX+ 32 - 32 | 4061264398568 | 14564421001 | 1584 | https://oxomi.com/p/3000126/datasheet/-/14564421001 | 0.194
1078434 | Sleeve : LX 7,4 | 30.5 | 40 | 40 mmø-40 mmø | 0.0000749691 | REHAU Coupling RAUTITAN RX+ 50 - 50 | 4061264397165 | 14563021001 | 1587 | https://oxomi.com/p/3000126/datasheet/-/14563021001 | 0.595
1078436 | Sleeve : LX 7,4 | 39.5 | 50 | 50 mmø-50 mmø | 0.000126985 | REHAU Coupling RAUTITAN RX+ 63 - 63 | 4061264397172 | 14563031001 | 1588 | https://oxomi.com/p/3000126/datasheet/-/14563031001 | 0.998

# IfcPipeFitting: RAUTITAN_WM_Corner_RP_LX_AU:12 RP 1/2 Left (8)
In: REHAU Starting view
Type - Material: Brass
Type - Other - Category: Pipe Fittings; Connection Down: yes; Connection Left: no; Connection Rear: no; Connection Right: no; Backplate Left: no; Backplate Right: yes; Family Name: RAUTITAN_WM_Corner_RP_LX_AU; Opening Left: no; Opening Right: yes; T1: RTI WM Corner RP LX P1; T2: RTI WM Corner RP LX
Type - Constraints - Default Elevation: 0.0131234 mm
Type - Dimensions - Di1: 9.9 mm; DN1: 12 mm; DN2: 15 mm
Type - Identity Data - Classification Number: 23.60.30.11.14; Manufacturer: REHAU; Model: RAUTITAN; Type Name: 12 RP 1/2 Left
Type - Pset_ManufacturerTypeInformation - Manufacturer: REHAU
Pset_EnvironmentalImpactIndicators - Reference: RAUTITAN_WM_Corner_RP_LX_AU:12 RP 1/2 Left; sets with these values: 2
Other - IsCustom: no; Family: RAUTITAN_WM_Corner_RP_LX_AU; Family and Type: RAUTITAN_WM_Corner_RP_LX_AU: 12 RP 1/2 Left; Type: 12 RP 1/2 Left; Type Id: 1191206
Constraints - Elevation from Level: 0 mm; Level: REHAU Starting view; Moves With Nearby Elements: no
Data - Language: Description EN; PID Check: 1 mm; Region Check: Check AU; Region PID: PID AU
Dimensions - Area: 0.0298753 m2; Volume: 0.0000319378 m3
Identity Data - Weight: 0
Phasing - Phase Created: New Construction
Insulation - Insulation Thickness: 0 mm
Name (RAUTITAN_WM_Corner_RP_LX_AU:12 RP 1/2 Left:...)
1238076
1238583
1238847
1238956
1238969
1239151
1239439
1239657

# IfcPipeFitting: RAUTITAN_WM_Corner_RP_LX_AU:12 RP 1/2 Rear Left, RAUTITAN_WM_Corner_RP_LX_AU:12 RP 1/2 Rear Left:1239513
In: REHAU Starting view
Type - Material: Brass
Type - Other - Category: Pipe Fittings; Backplate Right: no; Connection Left: no; Connection Right: no; Backplate Left: no; Opening Left: no; Opening Right: yes; Connection Down: no; Connection Rear: yes; Family Name: RAUTITAN_WM_Corner_RP_LX_AU; T1: RTI WM Corner RP LX P1; T2: RTI WM Corner RP LX
Type - Constraints - Default Elevation: 0.0131234 mm
Type - Dimensions - Di1: 9.9 mm; DN1: 12 mm; DN2: 15 mm
Type - Identity Data - Classification Number: 23.60.30.11.14; Manufacturer: REHAU; Model: RAUTITAN; Type Name: 12 RP 1/2 Rear Left
Type - Pset_ManufacturerTypeInformation - Manufacturer: REHAU
Pset_EnvironmentalImpactIndicators - Reference: RAUTITAN_WM_Corner_RP_LX_AU:12 RP 1/2 Rear Left; sets with these values: 2
Other - IsCustom: no; Family: RAUTITAN_WM_Corner_RP_LX_AU; Family and Type: RAUTITAN_WM_Corner_RP_LX_AU: 12 RP 1/2 Rear Left; Type: 12 RP 1/2 Rear Left; Type Id: 1201111
Constraints - Elevation from Level: 0 mm; Level: REHAU Starting view; Moves With Nearby Elements: no
Data - Language: Description EN; PID Check: 1 mm; Region Check: Check AU; Region PID: PID AU
Dimensions - Area: 0.0299057 m2; Volume: 0.0000329634 m3
Identity Data - Weight: 0
Phasing - Phase Created: New Construction
Insulation - Insulation Thickness: 0 mm

# IfcPipeFitting: RAUTITAN_WM_Corner_RP_LX_AU:12 RP 1/2 Rear Right, RAUTITAN_WM_Corner_RP_LX_AU:12 RP 1/2 Rear Right:1239511
In: REHAU Starting view
Type - Material: Brass
Type - Other - Category: Pipe Fittings; Backplate Right: no; Connection Left: no; Connection Right: no; Opening Left: yes; Opening Right: no; Backplate Left: no; Connection Down: no; Connection Rear: yes; Family Name: RAUTITAN_WM_Corner_RP_LX_AU; T1: RTI WM Corner RP LX P1; T2: RTI WM Corner RP LX
Type - Constraints - Default Elevation: 0.0131234 mm
Type - Dimensions - Di1: 9.9 mm; DN1: 12 mm; DN2: 15 mm
Type - Identity Data - Classification Number: 23.60.30.11.14; Manufacturer: REHAU; Model: RAUTITAN; Type Name: 12 RP 1/2 Rear Right
Type - Pset_ManufacturerTypeInformation - Manufacturer: REHAU
Pset_EnvironmentalImpactIndicators - Reference: RAUTITAN_WM_Corner_RP_LX_AU:12 RP 1/2 Rear Right; sets with these values: 2
Other - IsCustom: no; Family: RAUTITAN_WM_Corner_RP_LX_AU; Family and Type: RAUTITAN_WM_Corner_RP_LX_AU: 12 RP 1/2 Rear Right; Type: 12 RP 1/2 Rear Right; Type Id: 1201110
Constraints - Elevation from Level: 0 mm; Level: REHAU Starting view; Moves With Nearby Elements: no
Data - Language: Description EN; PID Check: 1 mm; Region Check: Check AU; Region PID: PID AU
Dimensions - Area: 0.0299057 m2; Volume: 0.0000331004 m3
Identity Data - Weight: 0
Phasing - Phase Created: New Construction
Insulation - Insulation Thickness: 0 mm

# IfcPipeFitting: RAUTITAN_WM_Corner_RP_LX_AU:12 RP 1/2 Right (8)
In: REHAU Starting view
Type - Material: Brass
Type - Other - Category: Pipe Fittings; Backplate Left: yes; Backplate Right: no; Connection Down: yes; Connection Left: no; Connection Rear: no; Connection Right: no; Family Name: RAUTITAN_WM_Corner_RP_LX_AU; Opening Left: yes; Opening Right: no; T1: RTI WM Corner RP LX P1; T2: RTI WM Corner RP LX
Type - Constraints - Default Elevation: 0.0131234 mm
Type - Dimensions - Di1: 9.9 mm; DN1: 12 mm; DN2: 15 mm
Type - Identity Data - Classification Number: 23.60.30.11.14; Manufacturer: REHAU; Model: RAUTITAN; Type Name: 12 RP 1/2 Right
Type - Pset_ManufacturerTypeInformation - Manufacturer: REHAU
Pset_EnvironmentalImpactIndicators - Reference: RAUTITAN_WM_Corner_RP_LX_AU:12 RP 1/2 Right; sets with these values: 2
Other - IsCustom: no; Family: RAUTITAN_WM_Corner_RP_LX_AU; Family and Type: RAUTITAN_WM_Corner_RP_LX_AU: 12 RP 1/2 Right; Type: 12 RP 1/2 Right; Type Id: 1191205
Constraints - Elevation from Level: 0 mm; Level: REHAU Starting view; Moves With Nearby Elements: no
Data - Language: Description EN; PID Check: 1 mm; Region Check: Check AU; Region PID: PID AU
Dimensions - Area: 0.0298753 m2; Volume: 0.000031902 m3
Identity Data - Weight: 0
Phasing - Phase Created: New Construction
Insulation - Insulation Thickness: 0 mm
Name (RAUTITAN_WM_Corner_RP_LX_AU:12 RP 1/2 Right:...)
1238075
1238599
1238845
1238955
1238967
1239149
1239527
1239655

# IfcPipeFitting: RAUTITAN_WM_Corner_RP_LX_AU:12 RP 1/2 Straight Left (5)
In: REHAU Starting view
Type - Material: Brass
Type - Other - Category: Pipe Fittings; Backplate Right: no; Connection Rear: no; Connection Right: no; Backplate Left: no; Opening Left: no; Opening Right: yes; Connection Down: no; Connection Left: yes; Family Name: RAUTITAN_WM_Corner_RP_LX_AU; T1: RTI WM Corner RP LX P1; T2: RTI WM Corner RP LX
Type - Constraints - Default Elevation: 0.0131234 mm
Type - Dimensions - Di1: 9.9 mm; DN1: 12 mm; DN2: 15 mm
Type - Identity Data - Classification Number: 23.60.30.11.14; Manufacturer: REHAU; Model: RAUTITAN; Type Name: 12 RP 1/2 Straight Left
Type - Pset_ManufacturerTypeInformation - Manufacturer: REHAU
Pset_EnvironmentalImpactIndicators - Reference: RAUTITAN_WM_Corner_RP_LX_AU:12 RP 1/2 Straight Left; sets with these values: 2
Other - IsCustom: no; Family: RAUTITAN_WM_Corner_RP_LX_AU; Family and Type: RAUTITAN_WM_Corner_RP_LX_AU: 12 RP 1/2 Straight Left; Type: 12 RP 1/2 Straight Left; Type Id: 1196113
Constraints - Elevation from Level: 0 mm; Level: REHAU Starting view; Moves With Nearby Elements: no
Data - Language: Description EN; PID Check: 1 mm; Region PID: PID AU
Dimensions - Area: 0.0298938 m2; Volume: 0.0000317919 m3
Identity Data - Weight: 0
Phasing - Phase Created: New Construction
Insulation - Insulation Thickness: 0 mm
Name (RAUTITAN_WM_Corner_RP_LX_AU:12 RP 1/2 Straight Left:...) | Region Check
1238349 | Check AU
1238601 | Check AU
1239226 | PID AU
1239301 | PID AU
1239529 | Check AU

# IfcPipeFitting: RAUTITAN_WM_Corner_RP_LX_AU:12 RP 1/2 Straight Right (5)
In: REHAU Starting view
Type - Material: Brass
Type - Other - Category: Pipe Fittings; Backplate Right: no; Connection Left: no; Connection Rear: no; Opening Left: yes; Opening Right: no; Backplate Left: no; Connection Down: no; Connection Right: yes; Family Name: RAUTITAN_WM_Corner_RP_LX_AU; T1: RTI WM Corner RP LX P1; T2: RTI WM Corner RP LX
Type - Constraints - Default Elevation: 0.0131234 mm
Type - Dimensions - Di1: 9.9 mm; DN1: 12 mm; DN2: 15 mm
Type - Identity Data - Classification Number: 23.60.30.11.14; Manufacturer: REHAU; Model: RAUTITAN; Type Name: 12 RP 1/2 Straight Right
Type - Pset_ManufacturerTypeInformation - Manufacturer: REHAU
Pset_EnvironmentalImpactIndicators - Reference: RAUTITAN_WM_Corner_RP_LX_AU:12 RP 1/2 Straight Right; sets with these values: 2
Other - IsCustom: no; Family: RAUTITAN_WM_Corner_RP_LX_AU; Family and Type: RAUTITAN_WM_Corner_RP_LX_AU: 12 RP 1/2 Straight Right; Type: 12 RP 1/2 Straight Right; Type Id: 1206120
Constraints - Elevation from Level: 0 mm; Level: REHAU Starting view; Moves With Nearby Elements: no
Data - Language: Description EN; PID Check: 1 mm; Region PID: PID AU
Dimensions - Area: 0.0298938 m2; Volume: 0.0000319298 m3
Identity Data - Weight: 0
Phasing - Phase Created: New Construction
Insulation - Insulation Thickness: 0 mm
Name (RAUTITAN_WM_Corner_RP_LX_AU:12 RP 1/2 Straight Right:...) | Region Check
1238347 | Check AU
1238581 | Check AU
1239224 | PID AU
1239299 | PID AU
1239437 | Check AU

# IfcPipeFitting: RAUTITAN_WM_Corner_RP_RX+:16 - RP1/2 Long (2)
In: REHAU Starting view
Type - Material: RAUTITAN RX+
Type - Other - Category: Pipe Fittings; Backplate: RTI_Backplate : 01; Frontplate: RTI_Frontplate : 05; V Backplate: yes; V Frontplate: no; Family Name: RAUTITAN_WM_Corner_RP_RX+; L1: 22.2 mm; L1+Z2: 25.8 mm; L4: 38.8 mm; L5: 52 mm; r1: 13 mm; r2: 10.2 mm; T1: RTI WM Corner RP RX P1; T2: RTI WM Corner RP RX; Z2: 3.6 mm; Z4: 17.1 mm
Type - Constraints - Default Elevation: 0 mm
Type - Data - Language: Description EN; Plate: 01; Region Check: Check DE; Region PID: PID DE; Type: Long
Type - Dimensions - Di1: 9.9 mm; Di2: 20.4 mm; DN1: 12 mm; DN2: 15 mm; Do2: 26 mm
Type - Identity Data - Classification Number: 23.60.30.11.14; Manufacturer: REHAU; Model: RAUTITAN; Type Name: 16 - RP1/2 Long
Type - Pset_ManufacturerTypeInformation - Manufacturer: REHAU
Pset_EnvironmentalImpactIndicators - Reference: RAUTITAN_WM_Corner_RP_RX+:16 - RP1/2 Long; sets with these values: 2
Other - IsCustom: no; Family: RAUTITAN_WM_Corner_RP_RX+; Family and Type: RAUTITAN_WM_Corner_RP_RX+: 16 - RP1/2 Long; Type: 16 - RP1/2 Long; Type Id: 1340796
Constraints - Elevation from Level: 0 mm; Level: REHAU Starting view; Moves With Nearby Elements: no
Data - PID Check: 1 mm
Dimensions - Angle test: 45 deg; Area: 0.0142064 m2; Volume: 0.0000216959 m3
Identity Data - Description long: REHAU Wall-mounted elbow RAUTITAN RX+ 16 - Rp 1/2 long; GTIN: 4061264397769; PID: 14563621001; Weight: 137
Phasing - Phase Created: New Construction
Insulation - Insulation Thickness: 0 mm
Name (RAUTITAN_WM_Corner_RP_RX+:16 - RP1/2 Long:...) | Ins. Box
1348564 | yes
1354022 | no

# IfcPipeFitting: RAUTITAN_WM_Corner_RP_RX+:16 - RP1/2 Short (2)
In: REHAU Starting view
Type - Material: RAUTITAN RX+
Type - Other - Category: Pipe Fittings; Backplate: RTI_Backplate : 01; Family Name: RAUTITAN_WM_Corner_RP_RX+; Frontplate: RTI_Frontplate : 05; L1: 22.2 mm; L1+Z2: 25.8 mm; L4: 26.8 mm; L5: 40 mm; r1: 13 mm; r2: 10.2 mm; T1: RTI WM Corner RP RX P1; T2: RTI WM Corner RP RX; V Backplate: yes; V Frontplate: no; Z2: 3.6 mm; Z4: 17.1 mm
Type - Constraints - Default Elevation: 0 mm
Type - Data - Language: Description EN; Plate: 01; Region Check: Check DE; Region PID: PID DE; Type: Short
Type - Dimensions - Di1: 9.9 mm; Di2: 20.4 mm; DN1: 12 mm; DN2: 15 mm; Do2: 26 mm
Type - Identity Data - Classification Number: 23.60.30.11.14; Manufacturer: REHAU; Model: RAUTITAN; Type Name: 16 - RP1/2 Short
Type - Pset_ManufacturerTypeInformation - Manufacturer: REHAU
Pset_EnvironmentalImpactIndicators - Reference: RAUTITAN_WM_Corner_RP_RX+:16 - RP1/2 Short; sets with these values: 2
Other - IsCustom: no; Family: RAUTITAN_WM_Corner_RP_RX+; Family and Type: RAUTITAN_WM_Corner_RP_RX+: 16 - RP1/2 Short; Type: 16 - RP1/2 Short; Type Id: 1340788
Constraints - Elevation from Level: 0 mm; Level: REHAU Starting view; Moves With Nearby Elements: no
Data - PID Check: 1 mm
Dimensions - Angle test: 45 deg; Area: 0.0133318 m2; Volume: 0.0000192367 m3
Identity Data - Description long: REHAU Wall-mounted elbow RAUTITAN RX+ 16 - Rp 1/2 short; GTIN: 4061264397721; PID: 14563581001; Weight: 127
Phasing - Phase Created: New Construction
Insulation - Insulation Thickness: 0 mm
Name (RAUTITAN_WM_Corner_RP_RX+:16 - RP1/2 Short:...) | Ins. Box
1086951 | no
1354062 | yes

# IfcPipeFitting: RAUTITAN_WM_Corner_RP_RX+:20 - RP1/2 Long (2)
In: REHAU Starting view
Type - Material: RAUTITAN RX+
Type - Other - Category: Pipe Fittings; Backplate: RTI_Backplate : 01; Frontplate: RTI_Frontplate : 05; V Backplate: yes; V Frontplate: no; Family Name: RAUTITAN_WM_Corner_RP_RX+; L1: 21 mm; L1+Z2: 24.8 mm; L4: 36.8 mm; L5: 52 mm; r1: 13 mm; r2: 10.2 mm; T1: RTI WM Corner RP RX P1; T2: RTI WM Corner RP RX; Z2: 3.8 mm; Z4: 20.1 mm
Type - Constraints - Default Elevation: 0 mm
Type - Data - Language: Description EN; Plate: 01; Region Check: Check DE; Region PID: PID DE; Type: Long
Type - Dimensions - Di1: 12.5 mm; Di2: 20.4 mm; DN1: 15 mm; DN2: 15 mm; Do2: 26 mm
Type - Identity Data - Classification Number: 23.60.30.11.14; Manufacturer: REHAU; Model: RAUTITAN; Type Name: 20 - RP1/2 Long
Type - Pset_ManufacturerTypeInformation - Manufacturer: REHAU
Pset_EnvironmentalImpactIndicators - Reference: RAUTITAN_WM_Corner_RP_RX+:20 - RP1/2 Long; sets with these values: 2
Other - IsCustom: no; Family: RAUTITAN_WM_Corner_RP_RX+; Family and Type: RAUTITAN_WM_Corner_RP_RX+: 20 - RP1/2 Long; Type: 20 - RP1/2 Long; Type Id: 1340798
Constraints - Elevation from Level: 0 mm; Level: REHAU Starting view; Moves With Nearby Elements: no
Data - PID Check: 1 mm
Dimensions - Angle test: 45 deg; Area: 0.0147273 m2; Volume: 0.0000231015 m3
Identity Data - Description long: REHAU Wall-mounted elbow RAUTITAN RX+ 20 - Rp 1/2 long; GTIN: 4061264397776; PID: 14563631001; Weight: 143
Phasing - Phase Created: New Construction
Insulation - Insulation Thickness: 0 mm
Name (RAUTITAN_WM_Corner_RP_RX+:20 - RP1/2 Long:...) | Ins. Box
1086955 | no
1354066 | yes

# IfcPipeFitting: RAUTITAN_WM_Corner_RP_RX+:20 - RP1/2 Short (2)
In: REHAU Starting view
Type - Material: RAUTITAN RX+
Type - Other - Category: Pipe Fittings; Backplate: RTI_Backplate : 01; Frontplate: RTI_Frontplate : 05; V Backplate: yes; V Frontplate: no; Family Name: RAUTITAN_WM_Corner_RP_RX+; L1: 21 mm; L1+Z2: 24.8 mm; L4: 24.8 mm; L5: 40 mm; r1: 13 mm; r2: 10.2 mm; T1: RTI WM Corner RP RX P1; T2: RTI WM Corner RP RX; Z2: 3.8 mm; Z4: 20.1 mm
Type - Constraints - Default Elevation: 0 mm
Type - Data - Language: Description EN; Plate: 01; Region Check: Check DE; Region PID: PID DE; Type: Short
Type - Dimensions - Di1: 12.5 mm; Di2: 20.4 mm; DN1: 15 mm; DN2: 15 mm; Do2: 26 mm
Type - Identity Data - Classification Number: 23.60.30.11.14; Manufacturer: REHAU; Model: RAUTITAN; Type Name: 20 - RP1/2 Short
Type - Pset_ManufacturerTypeInformation - Manufacturer: REHAU
Pset_EnvironmentalImpactIndicators - Reference: RAUTITAN_WM_Corner_RP_RX+:20 - RP1/2 Short; sets with these values: 2
Other - IsCustom: no; Family: RAUTITAN_WM_Corner_RP_RX+; Family and Type: RAUTITAN_WM_Corner_RP_RX+: 20 - RP1/2 Short; Type: 20 - RP1/2 Short; Type Id: 1340790
Constraints - Elevation from Level: 0 mm; Level: REHAU Starting view; Moves With Nearby Elements: no
Data - PID Check: 1 mm
Dimensions - Angle test: 45 deg; Area: 0.0138526 m2; Volume: 0.0000206423 m3
Identity Data - Description long: REHAU Wall-mounted elbow RAUTITAN RX+ 20 - Rp 1/2 short; GTIN: 4061264397738; PID: 14563591001; Weight: 121
Phasing - Phase Created: New Construction
Insulation - Insulation Thickness: 0 mm
Name (RAUTITAN_WM_Corner_RP_RX+:20 - RP1/2 Short:...) | Ins. Box
1086959 | no
1354070 | yes

# IfcPipeFitting: RAUTITAN_WM_Corner_RP_RX+:20 - RP3/4 Short, RAUTITAN_WM_Corner_RP_RX+:20 - RP3/4 Short:1086963
In: REHAU Starting view
Type - Material: RAUTITAN RX+
Type - Other - Category: Pipe Fittings; Backplate: RTI_Backplate : 01; Frontplate: RTI_Frontplate : 05; V Backplate: yes; V Frontplate: no; Family Name: RAUTITAN_WM_Corner_RP_RX+; L1: 24 mm; L1+Z2: 27.8 mm; L4: 24.8 mm; L5: 40 mm; r1: 16.25 mm; r2: 13.45 mm; T1: RTI WM Corner RP RX P1; T2: RTI WM Corner RP RX; Z2: 3.8 mm; Z4: 20.1 mm
Type - Constraints - Default Elevation: 0 mm
Type - Data - Language: Description EN; Plate: 01; Region Check: Check DE; Region PID: PID DE; Type: Short
Type - Dimensions - Di1: 12.5 mm; Di2: 26.9 mm; DN1: 15 mm; DN2: 20 mm; Do2: 32.5 mm
Type - Identity Data - Classification Number: 23.60.30.11.14; Manufacturer: REHAU; Model: RAUTITAN; Type Name: 20 - RP3/4 Short
Type - Pset_ManufacturerTypeInformation - Manufacturer: REHAU
Pset_EnvironmentalImpactIndicators - Reference: RAUTITAN_WM_Corner_RP_RX+:20 - RP3/4 Short; sets with these values: 2
Other - IsCustom: no; Family: RAUTITAN_WM_Corner_RP_RX+; Ins. Box: no; Family and Type: RAUTITAN_WM_Corner_RP_RX+: 20 - RP3/4 Short; Type: 20 - RP3/4 Short; Type Id: 1340792
Constraints - Elevation from Level: 0 mm; Level: REHAU Starting view; Moves With Nearby Elements: no
Data - PID Check: 1 mm
Dimensions - Angle test: 45 deg; Area: 0.0145612 m2; Volume: 0.0000225641 m3
Identity Data - Description long: REHAU Wall-mounted elbow RAUTITAN RX+ 20 - Rp 3/4 short; GTIN: 4061264397745; PID: 14563601001; Weight: 149
Phasing - Phase Created: New Construction
Insulation - Insulation Thickness: 0 mm

# IfcPipeFitting: RAUTITAN_WM_Corner_RP_RX+:25 - RP3/4 Short, RAUTITAN_WM_Corner_RP_RX+:25 - RP3/4 Short:1086967
In: REHAU Starting view
Type - Material: RAUTITAN RX+
Type - Other - Category: Pipe Fittings; Backplate: RTI_Backplate : 01; Frontplate: RTI_Frontplate : 05; V Backplate: yes; V Frontplate: no; Family Name: RAUTITAN_WM_Corner_RP_RX+; L1: 23.3 mm; L1+Z2: 28.2 mm; L4: 28.1 mm; L5: 45 mm; r1: 16.25 mm; r2: 13.45 mm; T1: RTI WM Corner RP RX P1; T2: RTI WM Corner RP RX; Z2: 4.9 mm; Z4: 25 mm
Type - Constraints - Default Elevation: 0 mm
Type - Data - Language: Description EN; Plate: 01; Region Check: Check DE; Region PID: PID DE; Type: Short
Type - Dimensions - Di1: 15.2 mm; Di2: 26.9 mm; DN1: 20 mm; DN2: 20 mm; Do2: 32.5 mm
Type - Identity Data - Classification Number: 23.60.30.11.14; Manufacturer: REHAU; Model: RAUTITAN; Type Name: 25 - RP3/4 Short
Type - Pset_ManufacturerTypeInformation - Manufacturer: REHAU
Pset_EnvironmentalImpactIndicators - Reference: RAUTITAN_WM_Corner_RP_RX+:25 - RP3/4 Short; sets with these values: 2
Other - IsCustom: no; Family: RAUTITAN_WM_Corner_RP_RX+; Ins. Box: no; Family and Type: RAUTITAN_WM_Corner_RP_RX+: 25 - RP3/4 Short; Type: 25 - RP3/4 Short; Type Id: 1340794
Constraints - Elevation from Level: 0 mm; Level: REHAU Starting view; Moves With Nearby Elements: no
Data - PID Check: 1 mm
Dimensions - Angle test: 45 deg; Area: 0.0161525 m2; Volume: 0.0000279633 m3
Identity Data - Description long: REHAU Wall-mounted elbow RAUTITAN RX+ 25 - Rp 3/4 short; GTIN: 4061264397752; PID: 14563611001; Weight: 181
Phasing - Phase Created: New Construction
Insulation - Insulation Thickness: 0 mm

# IfcPipeFitting: RAUTITAN_WM_Corner_RP_RX+:Assembly unit 55 16 - RP1/2, RAUTITAN_WM_Corner_RP_RX+:Assembly unit 55 16 - RP1/2:1086971
In: REHAU Starting view
Type - Material: RAUTITAN RX+
Type - Other - Category: Pipe Fittings; Frontplate: RTI_Frontplate : 05; Backplate: RTI_Backplate : 03; Family Name: RAUTITAN_WM_Corner_RP_RX+; L1: 22.2 mm; L1+Z2: 25.8 mm; L4: 69.2 mm; L5: 86.2 mm; r1: 13 mm; r2: 10.2 mm; T1: RTI WM Corner RP RX P1; T2: RTI WM Corner RP RX; V Backplate: no; V Frontplate: yes; Z2: 3.6 mm; Z4: 17.1 mm
Type - Constraints - Default Elevation: 0 mm
Type - Data - Language: Description EN; Plate: 05; Region Check: Check DE; Region PID: PID DE; Type: Assembly unit 55
Type - Dimensions - Di1: 9.9 mm; Di2: 20.4 mm; DN1: 12 mm; DN2: 15 mm; Do2: 26 mm
Type - Identity Data - Classification Number: 23.60.30.11.14; Manufacturer: REHAU; Model: RAUTITAN; Type Name: Assembly unit 55 16 - RP1/2
Type - Pset_ManufacturerTypeInformation - Manufacturer: REHAU
Pset_EnvironmentalImpactIndicators - Reference: RAUTITAN_WM_Corner_RP_RX+:Assembly unit 55 16 - RP1/2; sets with these values: 2
Other - IsCustom: no; Family: RAUTITAN_WM_Corner_RP_RX+; Ins. Box: no; Family and Type: RAUTITAN_WM_Corner_RP_RX+: Assembly unit 55 16 - RP1/2; Type: Assembly unit 55 16 - RP1/2; Type Id: 1340824
Constraints - Elevation from Level: 0 mm; Level: REHAU Starting view; Moves With Nearby Elements: no
Data - PID Check: 1 mm
Dimensions - Angle test: 45 deg; Area: 0.01651 m2; Volume: 0.0000307052 m3
Identity Data - Description long: REHAU Wall-mounted elbow RAUTITAN RX+ 16 - Rp 1/2 x 55 for assembly unit; GTIN: 4061264397936; PID: 14563791001; Weight: 244
Phasing - Phase Created: New Construction
Insulation - Insulation Thickness: 0 mm

# IfcPipeFitting: RAUTITAN_WM_Corner_RP_RX+:Chipboard 28 16 - RP1/2, RAUTITAN_WM_Corner_RP_RX+:Chipboard 28 16 - RP1/2:1086975
In: REHAU Starting view
Type - Material: RAUTITAN RX+
Type - Other - Category: Pipe Fittings; Backplate: RTI_Backplate : 03; V Backplate: no; V Frontplate: yes; Family Name: RAUTITAN_WM_Corner_RP_RX+; Frontplate: RTI_Frontplate : 04; L1: 22.2 mm; L1+Z2: 25.8 mm; L4: 42.2 mm; L5: 59.2 mm; r1: 13 mm; r2: 10.2 mm; T1: RTI WM Corner RP RX P1; T2: RTI WM Corner RP RX; Z2: 3.6 mm; Z4: 17.1 mm
Type - Constraints - Default Elevation: 0 mm
Type - Data - Language: Description EN; Plate: 04; Region Check: Check DE; Region PID: PID DE; Type: Chipboard 28
Type - Dimensions - Di1: 9.9 mm; Di2: 20.4 mm; DN1: 12 mm; DN2: 15 mm; Do2: 26 mm
Type - Identity Data - Classification Number: 23.60.30.11.14; Manufacturer: REHAU; Model: RAUTITAN; Type Name: Chipboard 28 16 - RP1/2
Type - Pset_ManufacturerTypeInformation - Manufacturer: REHAU
Pset_EnvironmentalImpactIndicators - Reference: RAUTITAN_WM_Corner_RP_RX+:Chipboard 28 16 - RP1/2; sets with these values: 2
Other - IsCustom: no; Family: RAUTITAN_WM_Corner_RP_RX+; Ins. Box: no; Family and Type: RAUTITAN_WM_Corner_RP_RX+: Chipboard 28 16 - RP1/2; Type: Chipboard 28 16 - RP1/2; Type Id: 1340816
Constraints - Elevation from Level: 0 mm; Level: REHAU Starting view; Moves With Nearby Elements: no
Data - PID Check: 1 mm
Dimensions - Angle test: 45 deg; Area: 0.0145421 m2; Volume: 0.0000263641 m3
Identity Data - Description long: REHAU Wall-mounted elbow RAUTITAN RX+ 16 - Rp 1/2 x 28 for chipboard; GTIN: 4061264397905; PID: 14563761001; Weight: 245
Phasing - Phase Created: New Construction
Insulation - Insulation Thickness: 0 mm

# IfcPipeFitting: RAUTITAN_WM_Corner_RP_RX+:Chipboard 28 20 - RP1/2, RAUTITAN_WM_Corner_RP_RX+:Chipboard 28 20 - RP1/2:1086979
In: REHAU Starting view
Type - Material: RAUTITAN RX+
Type - Other - Category: Pipe Fittings; Backplate: RTI_Backplate : 03; V Backplate: no; V Frontplate: yes; Frontplate: RTI_Frontplate : 04; Family Name: RAUTITAN_WM_Corner_RP_RX+; L1: 21 mm; L1+Z2: 24.8 mm; L4: 44.3 mm; L5: 61.3 mm; r1: 13 mm; r2: 10.2 mm; T1: RTI WM Corner RP RX P1; T2: RTI WM Corner RP RX; Z2: 3.8 mm; Z4: 20.1 mm
Type - Constraints - Default Elevation: 0 mm
Type - Data - Language: Description EN; Plate: 04; Region Check: Check DE; Region PID: PID DE; Type: Chipboard 28
Type - Dimensions - Di1: 12.5 mm; Di2: 20.4 mm; DN1: 15 mm; DN2: 15 mm; Do2: 26 mm
Type - Identity Data - Classification Number: 23.60.30.11.14; Manufacturer: REHAU; Model: RAUTITAN; Type Name: Chipboard 28 20 - RP1/2
Type - Pset_ManufacturerTypeInformation - Manufacturer: REHAU
Pset_EnvironmentalImpactIndicators - Reference: RAUTITAN_WM_Corner_RP_RX+:Chipboard 28 20 - RP1/2; sets with these values: 2
Other - IsCustom: no; Family: RAUTITAN_WM_Corner_RP_RX+; Ins. Box: no; Family and Type: RAUTITAN_WM_Corner_RP_RX+: Chipboard 28 20 - RP1/2; Type: Chipboard 28 20 - RP1/2; Type Id: 1340820
Constraints - Elevation from Level: 0 mm; Level: REHAU Starting view; Moves With Nearby Elements: no
Data - PID Check: 1 mm
Dimensions - Angle test: 45 deg; Area: 0.0153155 m2; Volume: 0.0000285383 m3
Identity Data - Description long: REHAU Wall-mounted elbow RAUTITAN RX+ 20 - Rp 1/2 x 28 for chipboard; GTIN: 4061264397912; PID: 14563771001; Weight: 212
Phasing - Phase Created: New Construction
Insulation - Insulation Thickness: 0 mm

# IfcPipeFitting: RAUTITAN_WM_Corner_RP_RX+:Chipboard 35 16 - RP1/2, RAUTITAN_WM_Corner_RP_RX+:Chipboard 35 16 - RP1/2:1086983
In: REHAU Starting view
Type - Material: RAUTITAN RX+
Type - Other - Category: Pipe Fittings; Frontplate: RTI_Frontplate : 05; Backplate: RTI_Backplate : 03; V Backplate: no; V Frontplate: yes; Family Name: RAUTITAN_WM_Corner_RP_RX+; L1: 22.2 mm; L1+Z2: 25.8 mm; L4: 49.2 mm; L5: 66.2 mm; r1: 13 mm; r2: 10.2 mm; T1: RTI WM Corner RP RX P1; T2: RTI WM Corner RP RX; Z2: 3.6 mm; Z4: 17.1 mm
Type - Constraints - Default Elevation: 0 mm
Type - Data - Language: Description EN; Plate: 05; Region Check: Check DE; Region PID: PID DE; Type: Chipboard 35
Type - Dimensions - Di1: 9.9 mm; Di2: 20.4 mm; DN1: 12 mm; DN2: 15 mm; Do2: 26 mm
Type - Identity Data - Classification Number: 23.60.30.11.14; Manufacturer: REHAU; Model: RAUTITAN; Type Name: Chipboard 35 16 - RP1/2
Type - Pset_ManufacturerTypeInformation - Manufacturer: REHAU
Pset_EnvironmentalImpactIndicators - Reference: RAUTITAN_WM_Corner_RP_RX+:Chipboard 35 16 - RP1/2; sets with these values: 2
Other - IsCustom: no; Family: RAUTITAN_WM_Corner_RP_RX+; Ins. Box: no; Family and Type: RAUTITAN_WM_Corner_RP_RX+: Chipboard 35 16 - RP1/2; Type: Chipboard 35 16 - RP1/2; Type Id: 1340818
Constraints - Elevation from Level: 0 mm; Level: REHAU Starting view; Moves With Nearby Elements: no
Data - PID Check: 1 mm
Dimensions - Angle test: 45 deg; Area: 0.0150523 m2; Volume: 0.0000266064 m3
Identity Data - Description long: REHAU Wall-mounted elbow RAUTITAN RX+ 16 - Rp 1/2 x 35 for chipboard; GTIN: 4061264398339; PID: 14564191001; Weight: 228
Phasing - Phase Created: New Construction
Insulation - Insulation Thickness: 0 mm

# IfcPipeFitting: RAUTITAN_WM_Corner_RP_RX+:Chipboard 55 16 - RP1/2, RAUTITAN_WM_Corner_RP_RX+:Chipboard 55 16 - RP1/2:1086987
In: REHAU Starting view
Type - Material: RAUTITAN RX+
Type - Other - Category: Pipe Fittings; Frontplate: RTI_Frontplate : 05; Backplate: RTI_Backplate : 03; V Backplate: no; V Frontplate: yes; Family Name: RAUTITAN_WM_Corner_RP_RX+; L1: 22.2 mm; L1+Z2: 25.8 mm; L4: 69.2 mm; L5: 86.2 mm; r1: 13 mm; r2: 10.2 mm; T1: RTI WM Corner RP RX P1; T2: RTI WM Corner RP RX; Z2: 3.6 mm; Z4: 17.1 mm
Type - Constraints - Default Elevation: 0 mm
Type - Data - Language: Description EN; Plate: 05; Region Check: Check DE; Region PID: PID DE; Type: Chipboard 55
Type - Dimensions - Di1: 9.9 mm; Di2: 20.4 mm; DN1: 12 mm; DN2: 15 mm; Do2: 26 mm
Type - Identity Data - Classification Number: 23.60.30.11.14; Manufacturer: REHAU; Model: RAUTITAN; Type Name: Chipboard 55 16 - RP1/2
Type - Pset_ManufacturerTypeInformation - Manufacturer: REHAU
Pset_EnvironmentalImpactIndicators - Reference: RAUTITAN_WM_Corner_RP_RX+:Chipboard 55 16 - RP1/2; sets with these values: 2
Other - IsCustom: no; Family: RAUTITAN_WM_Corner_RP_RX+; Ins. Box: no; Family and Type: RAUTITAN_WM_Corner_RP_RX+: Chipboard 55 16 - RP1/2; Type: Chipboard 55 16 - RP1/2; Type Id: 1340822
Constraints - Elevation from Level: 0 mm; Level: REHAU Starting view; Moves With Nearby Elements: no
Data - PID Check: 1 mm
Dimensions - Angle test: 45 deg; Area: 0.01651 m2; Volume: 0.0000307052 m3
Identity Data - Description long: REHAU Wall-mounted elbow RAUTITAN RX+ 16 - Rp 1/2 x 55 for chipboard; GTIN: 4061264397929; PID: 14563781001; Weight: 244
Phasing - Phase Created: New Construction
Insulation - Insulation Thickness: 0 mm

# IfcPipeFitting: RAUTITAN_WM_Corner_RP_RX+:Plasterboard 16 - RP1/2, RAUTITAN_WM_Corner_RP_RX+:Plasterboard 16 - RP1/2:1086991
In: REHAU Starting view
Type - Material: RAUTITAN RX+
Type - Other - Category: Pipe Fittings; Backplate: RTI_Backplate : 03; V Backplate: no; V Frontplate: yes; Frontplate: RTI_Frontplate : 04; Family Name: RAUTITAN_WM_Corner_RP_RX+; L1: 22.2 mm; L1+Z2: 25.8 mm; L4: 42.2 mm; L5: 59.2 mm; r1: 13 mm; r2: 10.2 mm; T1: RTI WM Corner RP RX P1; T2: RTI WM Corner RP RX; Z2: 3.6 mm; Z4: 17.1 mm
Type - Constraints - Default Elevation: 0 mm
Type - Data - Language: Description EN; Plate: 04; Region Check: Check DE; Region PID: PID DE; Type: Plasterboard
Type - Dimensions - Di1: 9.9 mm; Di2: 20.4 mm; DN1: 12 mm; DN2: 15 mm; Do2: 26 mm
Type - Identity Data - Classification Number: 23.60.30.11.14; Manufacturer: REHAU; Model: RAUTITAN; Type Name: Plasterboard 16 - RP1/2
Type - Pset_ManufacturerTypeInformation - Manufacturer: REHAU
Pset_EnvironmentalImpactIndicators - Reference: RAUTITAN_WM_Corner_RP_RX+:Plasterboard 16 - RP1/2; sets with these values: 2
Other - IsCustom: no; Family: RAUTITAN_WM_Corner_RP_RX+; Ins. Box: no; Family and Type: RAUTITAN_WM_Corner_RP_RX+: Plasterboard 16 - RP1/2; Type: Plasterboard 16 - RP1/2; Type Id: 1340812
Constraints - Elevation from Level: 0 mm; Level: REHAU Starting view; Moves With Nearby Elements: no
Data - PID Check: 1 mm
Dimensions - Angle test: 45 deg; Area: 0.0145421 m2; Volume: 0.0000263641 m3
Identity Data - Description long: REHAU Wall-mounted elbow RAUTITAN RX+ 16 - Rp 1/2 for plasterboard; GTIN: 4061264397882; PID: 14563741001; Weight: 202
Phasing - Phase Created: New Construction
Insulation - Insulation Thickness: 0 mm

# IfcPipeFitting: RAUTITAN_WM_Corner_RP_RX+:Plasterboard 20 - RP1/2, RAUTITAN_WM_Corner_RP_RX+:Plasterboard 20 - RP1/2:1086995
In: REHAU Starting view
Type - Material: RAUTITAN RX+
Type - Other - Category: Pipe Fittings; Backplate: RTI_Backplate : 03; V Backplate: no; V Frontplate: yes; Frontplate: RTI_Frontplate : 04; Family Name: RAUTITAN_WM_Corner_RP_RX+; L1: 21 mm; L1+Z2: 24.8 mm; L4: 44.3 mm; L5: 61.3 mm; r1: 13 mm; r2: 10.2 mm; T1: RTI WM Corner RP RX P1; T2: RTI WM Corner RP RX; Z2: 3.8 mm; Z4: 20.1 mm
Type - Constraints - Default Elevation: 0 mm
Type - Data - Language: Description EN; Plate: 04; Region Check: Check DE; Region PID: PID DE; Type: Plasterboard
Type - Dimensions - Di1: 12.5 mm; Di2: 20.4 mm; DN1: 15 mm; DN2: 15 mm; Do2: 26 mm
Type - Identity Data - Classification Number: 23.60.30.11.14; Manufacturer: REHAU; Model: RAUTITAN; Type Name: Plasterboard 20 - RP1/2
Type - Pset_ManufacturerTypeInformation - Manufacturer: REHAU
Pset_EnvironmentalImpactIndicators - Reference: RAUTITAN_WM_Corner_RP_RX+:Plasterboard 20 - RP1/2; sets with these values: 2
Other - IsCustom: no; Family: RAUTITAN_WM_Corner_RP_RX+; Ins. Box: no; Family and Type: RAUTITAN_WM_Corner_RP_RX+: Plasterboard 20 - RP1/2; Type: Plasterboard 20 - RP1/2; Type Id: 1340814
Constraints - Elevation from Level: 0 mm; Level: REHAU Starting view; Moves With Nearby Elements: no
Data - PID Check: 1 mm
Dimensions - Angle test: 45 deg; Area: 0.0153155 m2; Volume: 0.0000285383 m3
Identity Data - Description long: REHAU Wall-mounted elbow RAUTITAN RX+ 20 - Rp 1/2 for plasterboard; GTIN: 4061264397899; PID: 14563751001; Weight: 215
Phasing - Phase Created: New Construction
Insulation - Insulation Thickness: 0 mm

# IfcPipeFitting: RAUTITAN_WM_Corner_RP_RX+:Pre-wall 59 16 - RP1/2, RAUTITAN_WM_Corner_RP_RX+:Pre-wall 59 16 - RP1/2:1086999
In: REHAU Starting view
Type - Material: RAUTITAN RX+
Type - Other - Category: Pipe Fittings; Frontplate: RTI_Frontplate : 05; V Backplate: yes; V Frontplate: no; Backplate: RTI_Backplate : 03; Family Name: RAUTITAN_WM_Corner_RP_RX+; L1: 22.2 mm; L1+Z2: 25.8 mm; L4: 42.8 mm; L5: 57 mm; r1: 13 mm; r2: 10.2 mm; T1: RTI WM Corner RP RX P1; T2: RTI WM Corner RP RX; Z2: 3.6 mm; Z4: 17.1 mm
Type - Constraints - Default Elevation: 0 mm
Type - Data - Language: Description EN; Plate: 03; Region Check: Check DE; Region PID: PID DE; Type: Pre-wall 59
Type - Dimensions - Di1: 9.9 mm; Di2: 20.4 mm; DN1: 12 mm; DN2: 15 mm; Do2: 26 mm
Type - Identity Data - Classification Number: 23.60.30.11.14; Manufacturer: REHAU; Model: RAUTITAN; Type Name: Pre-wall 59 16 - RP1/2
Type - Pset_ManufacturerTypeInformation - Manufacturer: REHAU
