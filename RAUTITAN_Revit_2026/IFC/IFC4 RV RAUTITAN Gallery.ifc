Properties of the parts of a building model (IFC4), part 2 of 10

# IfcDistributionPort (986)
Name | FlowDirection
Port_1149273_0 | SOURCEANDSINK | SystemType: DOMESTICCOLDWATER; Group: Domestic Cold Water 1
Port_1149273_1 | SOURCEANDSINK | SystemType: DOMESTICCOLDWATER; Group: Domestic Cold Water 1
Port_1149513_0 | SOURCEANDSINK | SystemType: DOMESTICCOLDWATER; Group: Domestic Cold Water 2
Port_1149513_1 | SOURCEANDSINK | SystemType: DOMESTICCOLDWATER; Group: Domestic Cold Water 2
Port_1149556_0 | SOURCEANDSINK | SystemType: DOMESTICCOLDWATER; Group: Domestic Cold Water 3
Port_1149556_1 | SOURCEANDSINK | SystemType: DOMESTICCOLDWATER; Group: Domestic Cold Water 3
Port_1149576_0 | SOURCEANDSINK | SystemType: DOMESTICCOLDWATER; Group: Domestic Cold Water 4
Port_1149576_1 | SOURCEANDSINK | SystemType: DOMESTICCOLDWATER; Group: Domestic Cold Water 4
Port_1149581_0 | SOURCEANDSINK | SystemType: DOMESTICCOLDWATER; Group: Domestic Cold Water 5
Port_1149581_1 | SOURCEANDSINK | SystemType: DOMESTICCOLDWATER; Group: Domestic Cold Water 5
Port_1149586_0 | SOURCEANDSINK | SystemType: DOMESTICCOLDWATER; Group: Domestic Cold Water 6
Port_1149586_1 | SOURCEANDSINK | SystemType: DOMESTICCOLDWATER; Group: Domestic Cold Water 6
Port_1149591_0 | SOURCEANDSINK | SystemType: DOMESTICCOLDWATER; Group: Domestic Cold Water 7
Port_1149591_1 | SOURCEANDSINK | SystemType: DOMESTICCOLDWATER; Group: Domestic Cold Water 7
Port_1149905_0 | SOURCEANDSINK | SystemType: DOMESTICCOLDWATER; Group: Domestic Cold Water 8
Port_1149905_1 | SOURCEANDSINK | SystemType: DOMESTICCOLDWATER; Group: Domestic Cold Water 8
Port_1149987_0 | SOURCEANDSINK | SystemType: DOMESTICCOLDWATER; Group: Domestic Cold Water 9
Port_1149987_1 | SOURCEANDSINK | SystemType: DOMESTICCOLDWATER; Group: Domestic Cold Water 9
Port_1150002_0 | SOURCEANDSINK | SystemType: DOMESTICCOLDWATER; Group: Domestic Cold Water 10
Port_1150002_1 | SOURCEANDSINK | SystemType: DOMESTICCOLDWATER; Group: Domestic Cold Water 10
Port_1150007_0 | SOURCEANDSINK | SystemType: DOMESTICCOLDWATER; Group: Domestic Cold Water 11
Port_1150007_1 | SOURCEANDSINK | SystemType: DOMESTICCOLDWATER; Group: Domestic Cold Water 11
Port_1150012_0 | SOURCEANDSINK | SystemType: DOMESTICCOLDWATER; Group: Domestic Cold Water 12
Port_1150012_1 | SOURCEANDSINK | SystemType: DOMESTICCOLDWATER; Group: Domestic Cold Water 12
Port_1150017_0 | SOURCEANDSINK | SystemType: DOMESTICCOLDWATER; Group: Domestic Cold Water 13
Port_1150017_1 | SOURCEANDSINK | SystemType: DOMESTICCOLDWATER; Group: Domestic Cold Water 13
Port_1150022_0 | SOURCEANDSINK | SystemType: DOMESTICCOLDWATER; Group: Domestic Cold Water 14
Port_1150022_1 | SOURCEANDSINK | SystemType: DOMESTICCOLDWATER; Group: Domestic Cold Water 14
Port_1150027_0 | SOURCEANDSINK | SystemType: DOMESTICCOLDWATER; Group: Domestic Cold Water 15
Port_1150027_1 | SOURCEANDSINK | SystemType: DOMESTICCOLDWATER; Group: Domestic Cold Water 15
Port_1150371_0 | SOURCEANDSINK | SystemType: DOMESTICCOLDWATER; Group: Domestic Cold Water 16
Port_1150371_1 | SOURCEANDSINK | SystemType: DOMESTICCOLDWATER; Group: Domestic Cold Water 16
Port_1150374_0 | SOURCEANDSINK | SystemType: DOMESTICCOLDWATER; Group: Domestic Cold Water 17
Port_1150374_1 | SOURCEANDSINK | SystemType: DOMESTICCOLDWATER; Group: Domestic Cold Water 17
Port_1150376_0 | SOURCEANDSINK | SystemType: DOMESTICCOLDWATER; Group: Domestic Cold Water 18
Port_1150376_1 | SOURCEANDSINK | SystemType: DOMESTICCOLDWATER; Group: Domestic Cold Water 18
Port_1150378_0 | SOURCEANDSINK | SystemType: DOMESTICCOLDWATER; Group: Domestic Cold Water 19
Port_1150378_1 | SOURCEANDSINK | SystemType: DOMESTICCOLDWATER; Group: Domestic Cold Water 19
Port_1150380_0 | SOURCEANDSINK | SystemType: DOMESTICCOLDWATER; Group: Domestic Cold Water 20
Port_1150380_1 | SOURCEANDSINK | SystemType: DOMESTICCOLDWATER; Group: Domestic Cold Water 20
Port_1150382_0 | SOURCEANDSINK | SystemType: DOMESTICCOLDWATER; Group: Domestic Cold Water 21
Port_1150382_1 | SOURCEANDSINK | SystemType: DOMESTICCOLDWATER; Group: Domestic Cold Water 21
Port_1150384_0 | SOURCEANDSINK | SystemType: DOMESTICCOLDWATER; Group: Domestic Cold Water 22
Port_1150384_1 | SOURCEANDSINK | SystemType: DOMESTICCOLDWATER; Group: Domestic Cold Water 22
Port_1150500_0 | SOURCEANDSINK | SystemType: DOMESTICCOLDWATER; Group: Domestic Cold Water 24
Port_1150500_1 | SOURCEANDSINK | SystemType: DOMESTICCOLDWATER; Group: Domestic Cold Water 24
Port_1150502_0 | SOURCEANDSINK | SystemType: DOMESTICCOLDWATER; Group: Domestic Cold Water 25
Port_1150502_1 | SOURCEANDSINK | SystemType: DOMESTICCOLDWATER; Group: Domestic Cold Water 25
Port_1150504_0 | SOURCEANDSINK | SystemType: DOMESTICCOLDWATER; Group: Domestic Cold Water 26
Port_1150504_1 | SOURCEANDSINK | SystemType: DOMESTICCOLDWATER; Group: Domestic Cold Water 26
Port_1150506_0 | SOURCEANDSINK | SystemType: DOMESTICCOLDWATER; Group: Domestic Cold Water 27
Port_1150506_1 | SOURCEANDSINK | SystemType: DOMESTICCOLDWATER; Group: Domestic Cold Water 27
Port_1150508_0 | SOURCEANDSINK | SystemType: DOMESTICCOLDWATER; Group: Domestic Cold Water 28
Port_1150508_1 | SOURCEANDSINK | SystemType: DOMESTICCOLDWATER; Group: Domestic Cold Water 28
Port_1150510_0 | SOURCEANDSINK | SystemType: DOMESTICCOLDWATER; Group: Domestic Cold Water 29
Port_1150510_1 | SOURCEANDSINK | SystemType: DOMESTICCOLDWATER; Group: Domestic Cold Water 29
Port_1150512_0 | SOURCEANDSINK | SystemType: DOMESTICCOLDWATER; Group: Domestic Cold Water 30
Port_1150512_1 | SOURCEANDSINK | SystemType: DOMESTICCOLDWATER; Group: Domestic Cold Water 30
Port_1150838_0 | SOURCEANDSINK | SystemType: DOMESTICCOLDWATER; Group: Domestic Cold Water 23
Port_1150838_1 | SOURCEANDSINK | SystemType: DOMESTICCOLDWATER; Group: Domestic Cold Water 23
Port_1150842_0 | SOURCEANDSINK | SystemType: DOMESTICCOLDWATER; Group: Domestic Cold Water 31
Port_1150842_1 | SOURCEANDSINK | SystemType: DOMESTICCOLDWATER; Group: Domestic Cold Water 31
Port_1150844_0 | SOURCEANDSINK | SystemType: DOMESTICCOLDWATER; Group: Domestic Cold Water 32
Port_1150844_1 | SOURCEANDSINK | SystemType: DOMESTICCOLDWATER; Group: Domestic Cold Water 32
Port_1150846_0 | SOURCEANDSINK | SystemType: DOMESTICCOLDWATER; Group: Domestic Cold Water 33
Port_1150846_1 | SOURCEANDSINK | SystemType: DOMESTICCOLDWATER; Group: Domestic Cold Water 33
Port_1150848_0 | SOURCEANDSINK | SystemType: DOMESTICCOLDWATER; Group: Domestic Cold Water 34
Port_1150848_1 | SOURCEANDSINK | SystemType: DOMESTICCOLDWATER; Group: Domestic Cold Water 34
Port_1150850_0 | SOURCEANDSINK | SystemType: DOMESTICCOLDWATER; Group: Domestic Cold Water 35
Port_1150850_1 | SOURCEANDSINK | SystemType: DOMESTICCOLDWATER; Group: Domestic Cold Water 35
Port_1150852_0 | SOURCEANDSINK | SystemType: DOMESTICCOLDWATER; Group: Domestic Cold Water 36
Port_1150852_1 | SOURCEANDSINK | SystemType: DOMESTICCOLDWATER; Group: Domestic Cold Water 36
Port_1150856_0 | SOURCEANDSINK | SystemType: DOMESTICCOLDWATER; Group: Domestic Cold Water 38
Port_1150856_1 | SOURCEANDSINK | SystemType: DOMESTICCOLDWATER; Group: Domestic Cold Water 38
Port_1150860_0 | SOURCEANDSINK | SystemType: DOMESTICCOLDWATER; Group: Domestic Cold Water 40
Port_1150860_1 | SOURCEANDSINK | SystemType: DOMESTICCOLDWATER; Group: Domestic Cold Water 40
Port_1150862_0 | SOURCEANDSINK | SystemType: DOMESTICCOLDWATER; Group: Domestic Cold Water 41
Port_1150862_1 | SOURCEANDSINK | SystemType: DOMESTICCOLDWATER; Group: Domestic Cold Water 41
Port_1150864_0 | SOURCEANDSINK | SystemType: DOMESTICCOLDWATER; Group: Domestic Cold Water 42
Port_1150864_1 | SOURCEANDSINK | SystemType: DOMESTICCOLDWATER; Group: Domestic Cold Water 42
Port_1150866_0 | SOURCEANDSINK | SystemType: DOMESTICCOLDWATER; Group: Domestic Cold Water 43
Port_1150866_1 | SOURCEANDSINK | SystemType: DOMESTICCOLDWATER; Group: Domestic Cold Water 43
Port_1150868_0 | SOURCEANDSINK | SystemType: DOMESTICCOLDWATER; Group: Domestic Cold Water 44
Port_1150868_1 | SOURCEANDSINK | SystemType: DOMESTICCOLDWATER; Group: Domestic Cold Water 44
Port_1151148_0 | SOURCEANDSINK | SystemType: DOMESTICCOLDWATER; Group: Domestic Cold Water 37
Port_1151148_1 | SOURCEANDSINK | SystemType: DOMESTICCOLDWATER; Group: Domestic Cold Water 37
Port_1151185_0 | SOURCEANDSINK | SystemType: DOMESTICCOLDWATER; Group: Domestic Cold Water 45
Port_1151185_1 | SOURCEANDSINK | SystemType: DOMESTICCOLDWATER; Group: Domestic Cold Water 45
Port_1151187_0 | SOURCEANDSINK | SystemType: DOMESTICCOLDWATER; Group: Domestic Cold Water 46
Port_1151187_1 | SOURCEANDSINK | SystemType: DOMESTICCOLDWATER; Group: Domestic Cold Water 46
Port_1151189_0 | SOURCEANDSINK | SystemType: DOMESTICCOLDWATER; Group: Domestic Cold Water 47
Port_1151189_1 | SOURCEANDSINK | SystemType: DOMESTICCOLDWATER; Group: Domestic Cold Water 47
Port_1151191_0 | SOURCEANDSINK | SystemType: DOMESTICCOLDWATER; Group: Domestic Cold Water 48
Port_1151191_1 | SOURCEANDSINK | SystemType: DOMESTICCOLDWATER; Group: Domestic Cold Water 48
Port_1151193_0 | SOURCEANDSINK | SystemType: DOMESTICCOLDWATER; Group: Domestic Cold Water 49
Port_1151193_1 | SOURCEANDSINK | SystemType: DOMESTICCOLDWATER; Group: Domestic Cold Water 49
Port_1151195_0 | SOURCEANDSINK | SystemType: DOMESTICCOLDWATER; Group: Domestic Cold Water 50
Port_1151195_1 | SOURCEANDSINK | SystemType: DOMESTICCOLDWATER; Group: Domestic Cold Water 50
Port_1151197_0 | SOURCEANDSINK | SystemType: DOMESTICCOLDWATER; Group: Domestic Cold Water 51
Port_1151197_1 | SOURCEANDSINK | SystemType: DOMESTICCOLDWATER; Group: Domestic Cold Water 51
Port_1151436_0 | SOURCEANDSINK | SystemType: DOMESTICCOLDWATER; Group: Domestic Cold Water 39
Port_1151436_1 | SOURCEANDSINK | SystemType: DOMESTICCOLDWATER; Group: Domestic Cold Water 39
Port_1151469_0 | SOURCEANDSINK | SystemType: DOMESTICCOLDWATER; Group: Domestic Cold Water 52
Port_1151469_1 | SOURCEANDSINK | SystemType: DOMESTICCOLDWATER; Group: Domestic Cold Water 52
Port_1151471_0 | SOURCEANDSINK | SystemType: DOMESTICCOLDWATER; Group: Domestic Cold Water 53
Port_1151471_1 | SOURCEANDSINK | SystemType: DOMESTICCOLDWATER; Group: Domestic Cold Water 53
Port_1151473_0 | SOURCEANDSINK | SystemType: DOMESTICCOLDWATER; Group: Domestic Cold Water 54
Port_1151473_1 | SOURCEANDSINK | SystemType: DOMESTICCOLDWATER; Group: Domestic Cold Water 54
Port_1151475_0 | SOURCEANDSINK | SystemType: DOMESTICCOLDWATER; Group: Domestic Cold Water 55
Port_1151475_1 | SOURCEANDSINK | SystemType: DOMESTICCOLDWATER; Group: Domestic Cold Water 55
Port_1151477_0 | SOURCEANDSINK | SystemType: DOMESTICCOLDWATER; Group: Domestic Cold Water 56
Port_1151477_1 | SOURCEANDSINK | SystemType: DOMESTICCOLDWATER; Group: Domestic Cold Water 56
Port_1151479_0 | SOURCEANDSINK | SystemType: DOMESTICCOLDWATER; Group: Domestic Cold Water 57
Port_1151479_1 | SOURCEANDSINK | SystemType: DOMESTICCOLDWATER; Group: Domestic Cold Water 57
Port_1151481_0 | SOURCEANDSINK | SystemType: DOMESTICCOLDWATER; Group: Domestic Cold Water 58
Port_1151481_1 | SOURCEANDSINK | SystemType: DOMESTICCOLDWATER; Group: Domestic Cold Water 58
InPort_1238073_3 | SINK | SystemType: DOMESTICCOLDWATER
InPort_1238073_4 | SINK | SystemType: DOMESTICHOTWATER
InPort_1238318_1 | SINK | SystemType: DOMESTICCOLDWATER
InPort_1238318_2 | SINK | SystemType: DOMESTICHOTWATER
InPort_1238578_2 | SINK | SystemType: DOMESTICHOTWATER
InPort_1238578_3 | SINK | SystemType: DOMESTICCOLDWATER
InPort_1238596_1 | SINK | SystemType: DOMESTICCOLDWATER
InPort_1238596_2 | SINK | SystemType: DOMESTICHOTWATER
InPort_1238842_1 | SINK | SystemType: DOMESTICCOLDWATER
InPort_1238842_2 | SINK | SystemType: DOMESTICHOTWATER
InPort_1238953_3 | SINK | SystemType: DOMESTICCOLDWATER
InPort_1238953_4 | SINK | SystemType: DOMESTICHOTWATER
InPort_1238964_1 | SINK | SystemType: DOMESTICCOLDWATER
InPort_1238964_2 | SINK | SystemType: DOMESTICHOTWATER
InPort_1239135_1 | SINK | SystemType: DOMESTICCOLDWATER
InPort_1239135_2 | SINK | SystemType: DOMESTICHOTWATER
InPort_1239146_1 | SINK | SystemType: DOMESTICCOLDWATER
InPort_1239146_2 | SINK | SystemType: DOMESTICHOTWATER
InPort_1239298_1 | SINK | SystemType: DOMESTICCOLDWATER
InPort_1239298_2 | SINK | SystemType: DOMESTICHOTWATER
InPort_1239436_1 | SINK | SystemType: DOMESTICHOTWATER
InPort_1239436_2 | SINK | SystemType: DOMESTICCOLDWATER
InPort_1239510_1 | SINK | SystemType: DOMESTICHOTWATER
InPort_1239510_2 | SINK | SystemType: DOMESTICCOLDWATER
InPort_1239526_2 | SINK | SystemType: DOMESTICHOTWATER
InPort_1239526_3 | SINK | SystemType: HEATING
InPort_1239654_1 | SINK | SystemType: DOMESTICCOLDWATER
InPort_1239654_2 | SINK | SystemType: DOMESTICHOTWATER
Port_1356245_3 | SOURCEANDSINK
Port_1356245_4 | SOURCEANDSINK
Port_1440894_1 | SOURCEANDSINK
Port_1440894_2 | SOURCEANDSINK
Port_1440940_1 | SOURCEANDSINK
Port_1440940_2 | SOURCEANDSINK
Port_1441230_1 | SOURCEANDSINK
Port_1441230_2 | SOURCEANDSINK
Port_1441482_1 | SOURCEANDSINK | SystemType: HEATING
Port_1441482_2 | SOURCEANDSINK | SystemType: HEATING
Port_1441482_3 | SOURCEANDSINK | SystemType: HEATING
Port_1441702_2 | SOURCEANDSINK
Port_1441702_3 | SOURCEANDSINK
Port_1441967_2 | SOURCEANDSINK
Port_1441967_3 | SOURCEANDSINK
Port_1442034_2 | SOURCEANDSINK
Port_1442034_3 | SOURCEANDSINK
Port_1442377_1 | SOURCEANDSINK | SystemType: HEATING
Port_1442377_2 | SOURCEANDSINK | SystemType: HEATING
Port_1442377_3 | SOURCEANDSINK | SystemType: HEATING
Port_1442400_1 | SOURCEANDSINK
Port_1442400_2 | SOURCEANDSINK
Port_1442404_1 | SOURCEANDSINK
Port_1442404_2 | SOURCEANDSINK
Port_1442918_2 | SOURCEANDSINK
Port_1442918_3 | SOURCEANDSINK
Port_1442920_2 | SOURCEANDSINK
Port_1442920_3 | SOURCEANDSINK
Port_1442922_2 | SOURCEANDSINK
Port_1442922_3 | SOURCEANDSINK
Port_1442924_2 | SOURCEANDSINK
Port_1442924_3 | SOURCEANDSINK
Port_1442926_2 | SOURCEANDSINK
Port_1442926_3 | SOURCEANDSINK
Port_1442928_2 | SOURCEANDSINK
Port_1442928_3 | SOURCEANDSINK
Port_1442930_2 | SOURCEANDSINK
Port_1442930_3 | SOURCEANDSINK
Port_1442932_2 | SOURCEANDSINK
Port_1442932_3 | SOURCEANDSINK
Port_1442934_2 | SOURCEANDSINK
Port_1442934_3 | SOURCEANDSINK
Port_1442936_2 | SOURCEANDSINK
Port_1442936_3 | SOURCEANDSINK
Port_1442938_2 | SOURCEANDSINK
Port_1442938_3 | SOURCEANDSINK
Port_1443065_2 | SOURCEANDSINK
Port_1443065_3 | SOURCEANDSINK
Port_1443069_2 | SOURCEANDSINK
Port_1443069_3 | SOURCEANDSINK
Port_1443131_2 | SOURCEANDSINK
Port_1443131_3 | SOURCEANDSINK
Port_1443285_2 | SOURCEANDSINK
Port_1443285_3 | SOURCEANDSINK
Port_1443667_4 | SOURCEANDSINK
Port_1443667_5 | SOURCEANDSINK
Port_1443731_4 | SOURCEANDSINK
Port_1443731_5 | SOURCEANDSINK
Port_1443735_4 | SOURCEANDSINK
Port_1443735_5 | SOURCEANDSINK
Port_1443739_4 | SOURCEANDSINK
Port_1443739_5 | SOURCEANDSINK
Port_1443743_4 | SOURCEANDSINK
Port_1443743_5 | SOURCEANDSINK
Port_1443747_4 | SOURCEANDSINK
Port_1443747_5 | SOURCEANDSINK
Port_1443751_4 | SOURCEANDSINK
Port_1443751_5 | SOURCEANDSINK
Port_1443755_4 | SOURCEANDSINK
Port_1443755_5 | SOURCEANDSINK
Port_1443803_4 | SOURCEANDSINK
Port_1443803_5 | SOURCEANDSINK
Port_1443947_2 | SOURCEANDSINK
Port_1443947_3 | SOURCEANDSINK
Port_1443949_2 | SOURCEANDSINK
Port_1443949_3 | SOURCEANDSINK
Port_1443951_2 | SOURCEANDSINK
Port_1443951_3 | SOURCEANDSINK
Port_1443953_2 | SOURCEANDSINK
Port_1443953_3 | SOURCEANDSINK
Port_1443955_2 | SOURCEANDSINK
Port_1443955_3 | SOURCEANDSINK
Port_1443957_2 | SOURCEANDSINK
Port_1443957_3 | SOURCEANDSINK
Port_1443959_2 | SOURCEANDSINK
Port_1443959_3 | SOURCEANDSINK
Port_1443961_2 | SOURCEANDSINK
Port_1443961_3 | SOURCEANDSINK
Port_1444107_2 | SOURCEANDSINK
Port_1444107_3 | SOURCEANDSINK
Port_1444109_2 | SOURCEANDSINK
Port_1444109_3 | SOURCEANDSINK
Port_1444129_2 | SOURCEANDSINK
Port_1444129_3 | SOURCEANDSINK
Port_1444131_2 | SOURCEANDSINK
Port_1444131_3 | SOURCEANDSINK
Port_1444898_1 | SOURCEANDSINK
Port_1444898_2 | SOURCEANDSINK
Port_1444902_1 | SOURCEANDSINK
Port_1444902_2 | SOURCEANDSINK
Port_1444902_3 | SOURCEANDSINK
Port_1444910_1 | SOURCEANDSINK
Port_1444912_1 | SOURCEANDSINK
Port_1444912_2 | SOURCEANDSINK
Port_1444912_5 | SOURCEANDSINK
Port_1444912_6 | SOURCEANDSINK
Port_1444918_1 | SOURCEANDSINK
Port_1444918_2 | SOURCEANDSINK
Port_1444918_3 | SOURCEANDSINK
Port_1444918_4 | SOURCEANDSINK
Port_1444918_5 | SOURCEANDSINK
Port_1444926_1 | SOURCEANDSINK
Port_1444930_1 | SOURCEANDSINK
Port_1444930_2 | SOURCEANDSINK
Port_1444940_1 | SOURCEANDSINK
Port_1444940_2 | SOURCEANDSINK
Port_1444940_3 | SOURCEANDSINK
Port_1444946_1 | SOURCEANDSINK
Port_1444946_2 | SOURCEANDSINK
Port_1444946_3 | SOURCEANDSINK
Port_1444952_1 | SOURCEANDSINK
Port_1444952_2 | SOURCEANDSINK
Port_1444952_3 | SOURCEANDSINK
Port_1444958_1 | SOURCEANDSINK
Port_1444958_2 | SOURCEANDSINK
Port_1444962_1 | SOURCEANDSINK
Port_1444962_2 | SOURCEANDSINK
Port_1444966_1 | SOURCEANDSINK
Port_1444966_2 | SOURCEANDSINK
Port_1444970_1 | SOURCEANDSINK
Port_1444970_2 | SOURCEANDSINK
Port_1444974_1 | SOURCEANDSINK
Port_1444974_2 | SOURCEANDSINK
Port_1444978_1 | SOURCEANDSINK
Port_1444978_2 | SOURCEANDSINK
Port_1444982_1 | SOURCEANDSINK
Port_1444982_2 | SOURCEANDSINK
Port_1444986_1 | SOURCEANDSINK
Port_1444986_2 | SOURCEANDSINK
Port_1444990_1 | SOURCEANDSINK
Port_1444990_2 | SOURCEANDSINK
Port_1444994_1 | SOURCEANDSINK
Port_1444994_2 | SOURCEANDSINK
Port_1444998_1 | SOURCEANDSINK
Port_1444998_2 | SOURCEANDSINK
Port_1445002_1 | SOURCEANDSINK
Port_1445002_2 | SOURCEANDSINK
Port_1445002_3 | SOURCEANDSINK
Port_1445010_1 | SOURCEANDSINK
Port_1445010_2 | SOURCEANDSINK
Port_1445010_3 | SOURCEANDSINK
Port_1445018_1 | SOURCEANDSINK
Port_1445020_1 | SOURCEANDSINK
Port_1445020_2 | SOURCEANDSINK
Port_1445020_3 | SOURCEANDSINK
Port_1445020_4 | SOURCEANDSINK
Port_1445020_5 | SOURCEANDSINK
Port_1445028_1 | SOURCEANDSINK
Port_1445028_2 | SOURCEANDSINK
Port_1445028_5 | SOURCEANDSINK
Port_1445028_6 | SOURCEANDSINK
Port_1445034_1 | SOURCEANDSINK
Port_1445038_1 | SOURCEANDSINK
Port_1445038_2 | SOURCEANDSINK
Port_1445042_1 | SOURCEANDSINK
Port_1445042_2 | SOURCEANDSINK
Port_1445046_1 | SOURCEANDSINK
Port_1445046_2 | SOURCEANDSINK
Port_1445050_1 | SOURCEANDSINK
Port_1445050_2 | SOURCEANDSINK
Port_1445054_1 | SOURCEANDSINK
Port_1445054_2 | SOURCEANDSINK
Port_1445058_1 | SOURCEANDSINK
Port_1445058_2 | SOURCEANDSINK
Port_1445062_1 | SOURCEANDSINK
Port_1445062_2 | SOURCEANDSINK
Port_1445066_1 | SOURCEANDSINK
Port_1445066_2 | SOURCEANDSINK
Port_1445066_3 | SOURCEANDSINK
Port_1445078_1 | SOURCEANDSINK
Port_1445078_2 | SOURCEANDSINK
Port_1445078_3 | SOURCEANDSINK
Port_1445084_1 | SOURCEANDSINK
Port_1445084_2 | SOURCEANDSINK
Port_1445084_3 | SOURCEANDSINK
Port_1445090_1 | SOURCEANDSINK
Port_1445090_2 | SOURCEANDSINK
Port_1445090_3 | SOURCEANDSINK
Port_1445096_1 | SOURCEANDSINK
Port_1445096_2 | SOURCEANDSINK
Port_1445096_3 | SOURCEANDSINK
Port_1445102_1 | SOURCEANDSINK
Port_1445102_2 | SOURCEANDSINK
Port_1445102_3 | SOURCEANDSINK
Port_1445108_1 | SOURCEANDSINK
Port_1445108_2 | SOURCEANDSINK
Port_1445108_3 | SOURCEANDSINK
Port_1445114_1 | SOURCEANDSINK
Port_1445114_2 | SOURCEANDSINK
Port_1445114_3 | SOURCEANDSINK
Port_1445120_1 | SOURCEANDSINK
Port_1445120_2 | SOURCEANDSINK
Port_1445120_3 | SOURCEANDSINK
Port_1445126_1 | SOURCEANDSINK
Port_1445126_2 | SOURCEANDSINK
Port_1445126_3 | SOURCEANDSINK
Port_1445132_1 | SOURCEANDSINK
Port_1445132_2 | SOURCEANDSINK
Port_1445132_3 | SOURCEANDSINK
Port_1447317_1 | SOURCEANDSINK
Port_1447317_2 | SOURCEANDSINK
Port_1447317_3 | SOURCEANDSINK
Port_1447323_1 | SOURCEANDSINK
Port_1447323_2 | SOURCEANDSINK
Port_1447323_3 | SOURCEANDSINK
Port_1447698_1 | SOURCEANDSINK
Port_1447698_2 | SOURCEANDSINK
Port_1447702_1 | SOURCEANDSINK
Port_1447702_2 | SOURCEANDSINK
Port_1447706_1 | SOURCEANDSINK
Port_1447706_2 | SOURCEANDSINK
Port_1447710_1 | SOURCEANDSINK
Port_1447710_2 | SOURCEANDSINK
Port_1447714_1 | SOURCEANDSINK
Port_1447714_2 | SOURCEANDSINK
Port_1447718_1 | SOURCEANDSINK
Port_1447718_2 | SOURCEANDSINK
Port_1447722_1 | SOURCEANDSINK
Port_1447722_2 | SOURCEANDSINK
Port_1447726_1 | SOURCEANDSINK
Port_1447726_2 | SOURCEANDSINK
Port_1451456_1 | SOURCEANDSINK
Port_1451456_2 | SOURCEANDSINK
Port_1454191_1 | SOURCEANDSINK
Port_1454191_2 | SOURCEANDSINK

# IfcDistributionSystem: Domestic Cold Water (58)
PredefinedType: DOMESTICCOLDWATER
Pset_DistributionSystemCommon - Reference: Piping System:Domestic Cold Water
Name
Domestic Cold Water 1
Domestic Cold Water 2
Domestic Cold Water 3
Domestic Cold Water 4
Domestic Cold Water 5
Domestic Cold Water 6
Domestic Cold Water 7
Domestic Cold Water 8
Domestic Cold Water 9
Domestic Cold Water 10
Domestic Cold Water 11
Domestic Cold Water 12
Domestic Cold Water 13
Domestic Cold Water 14
Domestic Cold Water 15
Domestic Cold Water 16
Domestic Cold Water 17
Domestic Cold Water 18
Domestic Cold Water 19
Domestic Cold Water 20
Domestic Cold Water 21
Domestic Cold Water 22
Domestic Cold Water 24
Domestic Cold Water 25
Domestic Cold Water 26
Domestic Cold Water 27
Domestic Cold Water 28
Domestic Cold Water 29
Domestic Cold Water 30
Domestic Cold Water 23
Domestic Cold Water 31
Domestic Cold Water 32
Domestic Cold Water 33
Domestic Cold Water 34
Domestic Cold Water 35
Domestic Cold Water 36
Domestic Cold Water 38
Domestic Cold Water 40
Domestic Cold Water 41
Domestic Cold Water 42
Domestic Cold Water 43
Domestic Cold Water 44
Domestic Cold Water 37
Domestic Cold Water 45
Domestic Cold Water 46
Domestic Cold Water 47
Domestic Cold Water 48
Domestic Cold Water 49
Domestic Cold Water 50
Domestic Cold Water 51
Domestic Cold Water 39
Domestic Cold Water 52
Domestic Cold Water 53
Domestic Cold Water 54
Domestic Cold Water 55
Domestic Cold Water 56
Domestic Cold Water 57
Domestic Cold Water 58

# IfcFlowTerminal: RAUTITAN_Bath&Laundry Assembly Angle:12 Inch Angle, RAUTITAN_Bath&Laundry Assembly Angle:12 Inch Angle:1239654
In: REHAU Starting view
Type - Material: Brass, Copper
Type - Other - Category: Plumbing Fixtures; Connection Left: RAUTITAN_WM_Corner_RP_LX_AU : 12 RP 1/2 Left; Connection Right: RAUTITAN_WM_Corner_RP_LX_AU : 12 RP 1/2 Right; Family Name: RAUTITAN_Bath&Laundry Assembly Angle; MFT: Angle; T1: RTI BL Assembly
Type - Constraints - Default Elevation: 0 mm
Type - Data - Language: Description EN; Region Check: Check AU; Region PID: PID AU
Type - Dimensions - Width: 305 mm
Type - Identity Data - Manufacturer: REHAU; Model: RAUTITAN; REHAU Info: 2024.08.29-420668-420668; Type Name: 12 Inch Angle
Type - Pset_ManufacturerTypeInformation - Manufacturer: REHAU
Pset_EnvironmentalImpactIndicators - Reference: RAUTITAN_Bath&Laundry Assembly Angle:12 Inch Angle
Other - IsCustom: no; Family: RAUTITAN_Bath&Laundry Assembly Angle; Family and Type: RAUTITAN_Bath&Laundry Assembly Angle: 12 Inch Angle; Type: 12 Inch Angle; Type Id: 1191303
Constraints - Elevation from Level: 0 mm; Level: REHAU Starting view; Offset from Host: 0 mm; Host: Level : REHAU Starting view
Data - PID Check: 1 mm
Dimensions - Area: 0.0178767 m2; DN: 12 mm; Volume: 0.0000426834 m3
Identity Data - Description long: RAUTITAN BATH/LNDRY ASMBLY R/A 12"; GTIN: 4007360479572; Mark: 25; PID: 268881-401; Weight: 0
Mechanical - System Classification: Domestic Cold Water,Domestic Hot Water
Phasing - Phase Created: New Construction

# IfcFlowTerminal: RAUTITAN_Bath&Laundry Assembly Angle:8 Inch Angle, RAUTITAN_Bath&Laundry Assembly Angle:8 Inch Angle:1239146
In: REHAU Starting view
Type - Material: Brass, Copper
Type - Other - Category: Plumbing Fixtures; Connection Left: RAUTITAN_WM_Corner_RP_LX_AU : 12 RP 1/2 Left; Connection Right: RAUTITAN_WM_Corner_RP_LX_AU : 12 RP 1/2 Right; Family Name: RAUTITAN_Bath&Laundry Assembly Angle; MFT: Angle; T1: RTI BL Assembly
Type - Constraints - Default Elevation: 0 mm
Type - Data - Language: Description EN; Region Check: Check AU; Region PID: PID AU
Type - Dimensions - Width: 205 mm
Type - Identity Data - Manufacturer: REHAU; Model: RAUTITAN; REHAU Info: 2024.08.29-420668-420668; Type Name: 8 Inch Angle
Type - Pset_ManufacturerTypeInformation - Manufacturer: REHAU
Pset_EnvironmentalImpactIndicators - Reference: RAUTITAN_Bath&Laundry Assembly Angle:8 Inch Angle
Other - IsCustom: no; Type: 8 Inch Angle; Family: RAUTITAN_Bath&Laundry Assembly Angle; Family and Type: RAUTITAN_Bath&Laundry Assembly Angle: 8 Inch Angle; Type Id: 1191305
Constraints - Elevation from Level: 0 mm; Level: REHAU Starting view; Offset from Host: 0 mm; Host: Level : REHAU Starting view
Data - PID Check: 1 mm
Dimensions - Area: 0.0126303 m2; DN: 12 mm; Volume: 0.0000306171 m3
Identity Data - Description long: RAUTITAN BATH/LAUNDRY ASSEMBLY R/A 8"; GTIN: 4007360479534; Mark: 15; PID: 261955-401; Weight: 0
Mechanical - System Classification: Domestic Cold Water,Domestic Hot Water
Phasing - Phase Created: New Construction

# IfcFlowTerminal: RAUTITAN_Bath&Laundry Assembly Left straight:12 Inch Left straight, RAUTITAN_Bath&Laundry Assembly Left straight:12 Inch Left straight:1239526
In: REHAU Starting view
Type - Material: Brass, Copper
Type - Other - Category: Plumbing Fixtures; Connection Left: RAUTITAN_WM_Corner_RP_LX_AU : 12 RP 1/2 Straight Left; Connection Right: RAUTITAN_WM_Corner_RP_LX_AU : 12 RP 1/2 Right; Family Name: RAUTITAN_Bath&Laundry Assembly Left straight; MFT: Left Straight; T1: RTI BL Assembly
Type - Constraints - Default Elevation: 0 mm
Type - Data - Language: Description EN; Region Check: Check AU; Region PID: PID AU
Type - Dimensions - Width: 305 mm
Type - Identity Data - Manufacturer: REHAU; Model: RAUTITAN; REHAU Info: 2024.08.29-420668-420668; Type Name: 12 Inch Left straight
Type - Pset_ManufacturerTypeInformation - Manufacturer: REHAU
Pset_EnvironmentalImpactIndicators - Reference: RAUTITAN_Bath&Laundry Assembly Left straight:12 Inch Left straight
Other - IsCustom: no; Family: RAUTITAN_Bath&Laundry Assembly Left straight; Family and Type: RAUTITAN_Bath&Laundry Assembly Left straight: 12 Inch Left straight; Type: 12 Inch Left straight; Type Id: 1196299
Constraints - Elevation from Level: 0 mm; Level: REHAU Starting view; Offset from Host: 0 mm; Host: Level : REHAU Starting view
Data - PID Check: 1 mm
Dimensions - Area: 0.0178767 m2; DN: 12 mm; Volume: 0.0000426834 m3
Identity Data - Description long: RAUTITAN BATH/LNDRY ASSEMBLY L.H STR 12"; GTIN: 4007360479473; Mark: 24; PID: 245987-401; Weight: 0
Mechanical - System Classification: Domestic Hot Water,Hydronic Supply
Phasing - Phase Created: New Construction

# IfcFlowTerminal: RAUTITAN_Bath&Laundry Assembly Rear:12 Inch Rear, RAUTITAN_Bath&Laundry Assembly Rear:12 Inch Rear:1239510
In: REHAU Starting view
Type - Material: Brass, Copper
Type - Other - Category: Plumbing Fixtures; Connection Left: RAUTITAN_WM_Corner_RP_LX_AU : 12 RP 1/2 Rear Left; Connection Right: RAUTITAN_WM_Corner_RP_LX_AU : 12 RP 1/2 Rear Right; Family Name: RAUTITAN_Bath&Laundry Assembly Rear; MFT: Rear; T1: RTI BL Assembly
Type - Constraints - Default Elevation: 0 mm
Type - Data - Language: Description EN; Region Check: Check AU; Region PID: PID AU
Type - Dimensions - Width: 305 mm
Type - Identity Data - Manufacturer: REHAU; Model: RAUTITAN; REHAU Info: 2024.08.29-420668-420668; Type Name: 12 Inch Rear
Type - Pset_ManufacturerTypeInformation - Manufacturer: REHAU
Pset_EnvironmentalImpactIndicators - Reference: RAUTITAN_Bath&Laundry Assembly Rear:12 Inch Rear
Other - IsCustom: no; Family: RAUTITAN_Bath&Laundry Assembly Rear; Family and Type: RAUTITAN_Bath&Laundry Assembly Rear: 12 Inch Rear; Type: 12 Inch Rear; Type Id: 1201297
Constraints - Elevation from Level: 0 mm; Level: REHAU Starting view; Offset from Host: 0 mm; Host: Level : REHAU Starting view
Data - PID Check: 1 mm
Dimensions - Area: 0.0178767 m2; DN: 12 mm; Volume: 0.0000426834 m3
Identity Data - Description long: RAUTITAN BATH/LNDRY ASSEMBLY R-ENTRY 12"; GTIN: 4007360321352; Mark: 23; PID: 245997-001; Weight: 0
Mechanical - System Classification: Domestic Hot Water,Domestic Cold Water
Phasing - Phase Created: New Construction

# IfcFlowTerminal: RAUTITAN_Bath&Laundry Assembly Right straight:12 Inch Right straight, RAUTITAN_Bath&Laundry Assembly Right straight:12 Inch Right straight:1239436
In: REHAU Starting view
Type - Material: Brass, Copper
Type - Other - Category: Plumbing Fixtures; Connection Left: RAUTITAN_WM_Corner_RP_LX_AU : 12 RP 1/2 Left; Connection Right: RAUTITAN_WM_Corner_RP_LX_AU : 12 RP 1/2 Straight Right; Family Name: RAUTITAN_Bath&Laundry Assembly Right straight; MFT: Right Straight; T1: RTI BL Assembly
Type - Constraints - Default Elevation: 0 mm
Type - Data - Language: Description EN; Region Check: Check AU; Region PID: PID AU
Type - Dimensions - Width: 305 mm
Type - Identity Data - Manufacturer: REHAU; Model: RAUTITAN; REHAU Info: 2024.08.29-420668-420668; Type Name: 12 Inch Right straight
Type - Pset_ManufacturerTypeInformation - Manufacturer: REHAU
Pset_EnvironmentalImpactIndicators - Reference: RAUTITAN_Bath&Laundry Assembly Right straight:12 Inch Right straight
Other - IsCustom: no; Family: RAUTITAN_Bath&Laundry Assembly Right straight; Family and Type: RAUTITAN_Bath&Laundry Assembly Right straight: 12 Inch Right straight; Type: 12 Inch Right straight; Type Id: 1206306
Constraints - Elevation from Level: 0 mm; Level: REHAU Starting view; Offset from Host: 0 mm; Host: Level : REHAU Starting view
Data - PID Check: 1 mm
Dimensions - Area: 0.0178767 m2; DN: 12 mm; Volume: 0.0000426834 m3
Identity Data - Description long: RAUTITAN BATH/LNDRY ASSEMBLY R.H STR 12"; GTIN: 4007360479466; Mark: 22; PID: 245977-401; Weight: 0
Mechanical - System Classification: Domestic Hot Water,Domestic Cold Water
Phasing - Phase Created: New Construction

# IfcFlowTerminal: RAUTITAN_Bath&Laundry Assembly Straight:12 Inch Straight, RAUTITAN_Bath&Laundry Assembly Straight:12 Inch Straight:1239298
In: REHAU Starting view
Type - Material: Brass, Copper
Type - Other - Category: Plumbing Fixtures; Connection Left: RAUTITAN_WM_Corner_RP_LX_AU : 12 RP 1/2 Straight Left; Connection Right: RAUTITAN_WM_Corner_RP_LX_AU : 12 RP 1/2 Straight Right; Family Name: RAUTITAN_Bath&Laundry Assembly Straight; MFT: Straight; T1: RTI BL Assembly
Type - Constraints - Default Elevation: 0 mm
Type - Data - Language: Description EN; Region Check: Check AU; Region PID: PID AU
Type - Dimensions - Width: 305 mm
Type - Identity Data - Manufacturer: REHAU; Model: RAUTITAN; REHAU Info: 2024.08.26-420668-420668; Type Name: 12 Inch Straight
Type - Pset_ManufacturerTypeInformation - Manufacturer: REHAU
Pset_EnvironmentalImpactIndicators - Reference: RAUTITAN_Bath&Laundry Assembly Straight:12 Inch Straight
Other - IsCustom: no; Family: RAUTITAN_Bath&Laundry Assembly Straight; Family and Type: RAUTITAN_Bath&Laundry Assembly Straight: 12 Inch Straight; Type: 12 Inch Straight; Type Id: 1211314
Constraints - Elevation from Level: 0 mm; Level: REHAU Starting view; Offset from Host: 0 mm; Host: Level : REHAU Starting view
Data - PID Check: 1 mm
Dimensions - Area: 0.0178767 m2; DN: 12 mm; Volume: 0.0000426834 m3
Identity Data - Description long: RAUTITAN BATH/LNDRY STR 12"; GTIN: 4007360479565; Mark: 21; PID: 268871-401; Weight: 0
Mechanical - System Classification: Domestic Cold Water,Domestic Hot Water
Phasing - Phase Created: New Construction

# IfcFlowTerminal: RAUTITAN_Bath&Laundry Assembly Straight:8 Inch Straight, RAUTITAN_Bath&Laundry Assembly Straight:8 Inch Straight:1239135
In: REHAU Starting view
Type - Material: Brass, Copper
Type - Other - Category: Plumbing Fixtures; Connection Left: RAUTITAN_WM_Corner_RP_LX_AU : 12 RP 1/2 Straight Left; Connection Right: RAUTITAN_WM_Corner_RP_LX_AU : 12 RP 1/2 Straight Right; Family Name: RAUTITAN_Bath&Laundry Assembly Straight; MFT: Straight; T1: RTI BL Assembly
Type - Constraints - Default Elevation: 0 mm
Type - Data - Language: Description EN; Region Check: Check AU; Region PID: PID AU
Type - Dimensions - Width: 205 mm
Type - Identity Data - Manufacturer: REHAU; Model: RAUTITAN; REHAU Info: 2024.08.29-420668-420668; Type Name: 8 Inch Straight
Type - Pset_ManufacturerTypeInformation - Manufacturer: REHAU
Pset_EnvironmentalImpactIndicators - Reference: RAUTITAN_Bath&Laundry Assembly Straight:8 Inch Straight
Other - IsCustom: no; Family: RAUTITAN_Bath&Laundry Assembly Straight; Family and Type: RAUTITAN_Bath&Laundry Assembly Straight: 8 Inch Straight; Type: 8 Inch Straight; Type Id: 1211316
Constraints - Elevation from Level: 0 mm; Level: REHAU Starting view; Offset from Host: 0 mm; Host: Level : REHAU Starting view
Data - PID Check: 1 mm
Dimensions - Area: 0.0126303 m2; DN: 12 mm; Volume: 0.0000306171 m3
Identity Data - Description long: RAUTITAN BATH/LAUNDRY ASSEMBLY STR 8"; GTIN: 4007360479527; Mark: 14; PID: 261945-401; Weight: 0
Mechanical - System Classification: Domestic Cold Water,Domestic Hot Water
Phasing - Phase Created: New Construction

# IfcFlowTerminal: RAUTITAN_Shower Assembly Angle:6 Inch Angle, RAUTITAN_Shower Assembly Angle:6 Inch Angle:1238842
In: REHAU Starting view
Type - Material: Copper, Brass
Type - Other - Category: Plumbing Fixtures; Connection Left: RAUTITAN_WM_Corner_RP_LX_AU : 12 RP 1/2 Left; Connection Right: RAUTITAN_WM_Corner_RP_LX_AU : 12 RP 1/2 Right; Family Name: RAUTITAN_Shower Assembly Angle; MFT: Angle; T1: RTI S Assembly
Type - Constraints - Default Elevation: 0 mm
Type - Data - Language: Description EN; Region Check: Check AU; Region PID: PID AU
Type - Dimensions - Width: 150 mm
Type - Identity Data - Manufacturer: REHAU; Model: RAUTITAN; REHAU Info: 2024.08.29-420668-420668; Type Name: 6 Inch Angle
Type - Pset_ManufacturerTypeInformation - Manufacturer: REHAU
Pset_EnvironmentalImpactIndicators - Reference: RAUTITAN_Shower Assembly Angle:6 Inch Angle
Other - IsCustom: no; Family: RAUTITAN_Shower Assembly Angle; Family and Type: RAUTITAN_Shower Assembly Angle: 6 Inch Angle; Type: 6 Inch Angle; Type Id: 1216661
Constraints - Elevation from Level: 0 mm; Level: REHAU Starting view; Offset from Host: 0 mm; Host: Level : REHAU Starting view
Data - PID Check: 1 mm
Dimensions - Area: 0.0086062 m2; DN: 12 mm; Volume: 0.000019553 m3
Identity Data - Description long: RAUTITAN SHOWER ASSEMBLY R/A 6"; GTIN: 4007360479589; Mark: 6; PID: 268891-401; Weight: 0
Mechanical - System Classification: Domestic Cold Water,Domestic Hot Water
Phasing - Phase Created: New Construction

# IfcFlowTerminal: RAUTITAN_Shower Assembly Angle:8 Inch Angle, RAUTITAN_Shower Assembly Angle:8 Inch Angle:1238964
In: REHAU Starting view
Type - Material: Copper, Brass
Type - Other - Category: Plumbing Fixtures; Connection Left: RAUTITAN_WM_Corner_RP_LX_AU : 12 RP 1/2 Left; Connection Right: RAUTITAN_WM_Corner_RP_LX_AU : 12 RP 1/2 Right; Family Name: RAUTITAN_Shower Assembly Angle; MFT: Angle; T1: RTI S Assembly
Type - Constraints - Default Elevation: 0 mm
Type - Data - Language: Description EN; Region Check: Check AU; Region PID: PID AU
Type - Dimensions - Width: 205 mm
Type - Identity Data - Manufacturer: REHAU; Model: RAUTITAN; REHAU Info: 2024.08.29-420668-420668; Type Name: 8 Inch Angle
Type - Pset_ManufacturerTypeInformation - Manufacturer: REHAU
Pset_EnvironmentalImpactIndicators - Reference: RAUTITAN_Shower Assembly Angle:8 Inch Angle
Other - IsCustom: no; Family: RAUTITAN_Shower Assembly Angle; Family and Type: RAUTITAN_Shower Assembly Angle: 8 Inch Angle; Type: 8 Inch Angle; Type Id: 1216663
Constraints - Elevation from Level: 0 mm; Level: REHAU Starting view; Offset from Host: 0 mm; Host: Level : REHAU Starting view
Data - PID Check: 1 mm
Dimensions - Area: 0.0114917 m2; DN: 12 mm; Volume: 0.0000261897 m3
Identity Data - Description long: RAUTITAN SHOWER ASSEMBLY R/A 8"; GTIN: 4007360479541; Mark: 10; PID: 261965-401; Weight: 0
Mechanical - System Classification: Domestic Cold Water,Domestic Hot Water
Phasing - Phase Created: New Construction

# IfcFlowTerminal: RAUTITAN_Shower Assembly Left Straight:6 Inch Left straight, RAUTITAN_Shower Assembly Left Straight:6 Inch Left straight:1238596
In: REHAU Starting view
Type - Material: Copper, Brass
Type - Other - Category: Plumbing Fixtures; Connection Left: RAUTITAN_WM_Corner_RP_LX_AU : 12 RP 1/2 Straight Left; Connection Right: RAUTITAN_WM_Corner_RP_LX_AU : 12 RP 1/2 Right; Family Name: RAUTITAN_Shower Assembly Left Straight; MFT: Left Straight; T1: RTI S Assembly
Type - Constraints - Default Elevation: 0 mm
Type - Data - Language: Description EN; Region Check: Check AU; Region PID: PID AU
Type - Dimensions - Width: 150 mm
Type - Identity Data - Manufacturer: REHAU; Model: RAUTITAN; REHAU Info: 2024.08.29-420668-420668; Type Name: 6 Inch Left straight
Type - Pset_ManufacturerTypeInformation - Manufacturer: REHAU
Pset_EnvironmentalImpactIndicators - Reference: RAUTITAN_Shower Assembly Left Straight:6 Inch Left straight
Other - IsCustom: no; Family: RAUTITAN_Shower Assembly Left Straight; Family and Type: RAUTITAN_Shower Assembly Left Straight: 6 Inch Left straight; Type: 6 Inch Left straight; Type Id: 1222006
Constraints - Elevation from Level: 0 mm; Level: REHAU Starting view; Offset from Host: 0 mm; Host: Level : REHAU Starting view
Data - PID Check: 1 mm
Dimensions - Area: 0.0086062 m2; DN: 12 mm; Volume: 0.000019553 m3
Identity Data - Description long: RAUTITAN SHOWER ASSEMBLY L.H STRAIGHT 6"; GTIN: 4007360479503; Mark: 4; PID: 246117-401; Weight: 0
Mechanical - System Classification: Domestic Cold Water,Domestic Hot Water
Phasing - Phase Created: New Construction

# IfcFlowTerminal: RAUTITAN_Shower Assembly Right Straight:6 Inch Right Straight, RAUTITAN_Shower Assembly Right Straight:6 Inch Right Straight:1238578
In: REHAU Starting view
Type - Material: Copper, Brass
Type - Other - Category: Plumbing Fixtures; Connection Left: RAUTITAN_WM_Corner_RP_LX_AU : 12 RP 1/2 Left; Connection Right: RAUTITAN_WM_Corner_RP_LX_AU : 12 RP 1/2 Straight Right; Family Name: RAUTITAN_Shower Assembly Right Straight; MFT: Right Straight; T1: RTI S Assembly
Type - Constraints - Default Elevation: 0 mm
Type - Data - Language: Description EN; Region Check: Check AU; Region PID: PID AU
Type - Dimensions - Width: 150 mm
Type - Identity Data - Manufacturer: REHAU; Model: RAUTITAN; REHAU Info: 2024.08.29-420668-420668; Type Name: 6 Inch Right Straight
Type - Pset_ManufacturerTypeInformation - Manufacturer: REHAU
Pset_EnvironmentalImpactIndicators - Reference: RAUTITAN_Shower Assembly Right Straight:6 Inch Right Straight
Other - IsCustom: no; Family: RAUTITAN_Shower Assembly Right Straight; Family and Type: RAUTITAN_Shower Assembly Right Straight: 6 Inch Right Straight; Type: 6 Inch Right Straight; Type Id: 1227349
Constraints - Elevation from Level: 0 mm; Level: REHAU Starting view; Offset from Host: 0 mm; Host: Level : REHAU Starting view
Data - PID Check: 1 mm
Dimensions - Area: 0.0086062 m2; DN: 12 mm; Volume: 0.000019553 m3
Identity Data - Description long: RAUTITAN SHOWER ASSEMBLY R.H STRAIGHT 6"; GTIN: 4007360479510; Mark: 3; PID: 246127-401; Weight: 0
Mechanical - System Classification: Domestic Hot Water,Domestic Cold Water
Phasing - Phase Created: New Construction

# IfcFlowTerminal: RAUTITAN_Shower Assembly Straight:6 Inch Straight, RAUTITAN_Shower Assembly Straight:6 Inch Straight:1238318
In: REHAU Starting view
Type - Material: Copper, Brass
Type - Other - Category: Plumbing Fixtures; Connection Left: RAUTITAN_WM_Corner_RP_LX_AU : 12 RP 1/2 Straight Left; Connection Right: RAUTITAN_WM_Corner_RP_LX_AU : 12 RP 1/2 Straight Right; Family Name: RAUTITAN_Shower Assembly Straight; MFT: Straight; T1: RTI S Assembly
Type - Constraints - Default Elevation: 0 mm
Type - Data - Language: Description EN; Region Check: Check AU; Region PID: PID AU
Type - Dimensions - Width: 150 mm
Type - Identity Data - Manufacturer: REHAU; Model: RAUTITAN; REHAU Info: 2024.08.29-420668-420668; Type Name: 6 Inch Straight
Type - Pset_ManufacturerTypeInformation - Manufacturer: REHAU
Pset_EnvironmentalImpactIndicators - Reference: RAUTITAN_Shower Assembly Straight:6 Inch Straight
Other - IsCustom: no; Family: RAUTITAN_Shower Assembly Straight; Family and Type: RAUTITAN_Shower Assembly Straight: 6 Inch Straight; Type: 6 Inch Straight; Type Id: 1232692
Constraints - Elevation from Level: 0 mm; Level: REHAU Starting view; Offset from Host: 0 mm; Host: Level : REHAU Starting view
Data - PID Check: 1 mm
Dimensions - Area: 0.0086062 m2; DN: 12 mm; Volume: 0.000019553 m3
Identity Data - Description long: RAUTITAN SHOWER ASSEMBLY STRAIGHT 6"; GTIN: 4007360479558; Mark: 2; PID: 261995-401; Weight: 0
Mechanical - System Classification: Domestic Cold Water,Domestic Hot Water
Phasing - Phase Created: New Construction

# IfcFlowTerminal: RAUTITAN_Shower Assembly Up:6 Inch Up, RAUTITAN_Shower Assembly Up:6 Inch Up:1238073
In: REHAU Starting view
Type - Material: Copper, Brass
Type - Other - Category: Plumbing Fixtures; Connection Left: RAUTITAN_WM_Corner_RP_LX_AU : 12 RP 1/2 Left; Connection Right: RAUTITAN_WM_Corner_RP_LX_AU : 12 RP 1/2 Right; Family Name: RAUTITAN_Shower Assembly Up; MFT: Up; T1: RTI S Assembly
Type - Constraints - Default Elevation: 0 mm
Type - Data - Language: Description EN; Region Check: Check AU; Region PID: PID AU
Type - Dimensions - Width: 150 mm
Type - Identity Data - Manufacturer: REHAU; Model: RAUTITAN; REHAU Info: 2024.08.29-420668-420668; Type Name: 6 Inch Up
Type - Pset_ManufacturerTypeInformation - Manufacturer: REHAU
Pset_EnvironmentalImpactIndicators - Reference: RAUTITAN_Shower Assembly Up:6 Inch Up
Other - IsCustom: no; Family: RAUTITAN_Shower Assembly Up; Family and Type: RAUTITAN_Shower Assembly Up: 6 Inch Up; Type: 6 Inch Up; Type Id: 1238037
Constraints - Elevation from Level: 0 mm; Level: REHAU Starting view; Offset from Host: 0 mm; Host: Level : REHAU Starting view
Data - PID Check: 1 mm
Dimensions - Area: 0.0086062 m2; DN: 12 mm; Volume: 0.000019553 m3
Identity Data - Description long: RAUTITAN SHOWER ASSEMBLY B/U 6"; GTIN: 4007360479480; Mark: 1; PID: 246007-401; Weight: 0
Mechanical - System Classification: Domestic Cold Water,Domestic Hot Water
Phasing - Phase Created: New Construction

# IfcFlowTerminal: RAUTITAN_Shower Assembly Up:8 Inch Up, RAUTITAN_Shower Assembly Up:8 Inch Up:1238953
In: REHAU Starting view
Type - Material: Copper, Brass
Type - Other - Category: Plumbing Fixtures; Connection Left: RAUTITAN_WM_Corner_RP_LX_AU : 12 RP 1/2 Left; Connection Right: RAUTITAN_WM_Corner_RP_LX_AU : 12 RP 1/2 Right; Family Name: RAUTITAN_Shower Assembly Up; MFT: Up; T1: RTI S Assembly
Type - Constraints - Default Elevation: 0 mm
Type - Data - Language: Description EN; Region Check: Check AU; Region PID: PID AU
Type - Dimensions - Width: 205 mm
Type - Identity Data - Manufacturer: REHAU; Model: RAUTITAN; REHAU Info: 2024.08.29-420668-420668; Type Name: 8 Inch Up
Type - Pset_ManufacturerTypeInformation - Manufacturer: REHAU
Pset_EnvironmentalImpactIndicators - Reference: RAUTITAN_Shower Assembly Up:8 Inch Up
Other - IsCustom: no; Family: RAUTITAN_Shower Assembly Up; Family and Type: RAUTITAN_Shower Assembly Up: 8 Inch Up; Type: 8 Inch Up; Type Id: 1238039
Constraints - Elevation from Level: 0 mm; Level: REHAU Starting view; Offset from Host: 0 mm; Host: Level : REHAU Starting view
Data - PID Check: 1 mm
Dimensions - Area: 0.0114917 m2; DN: 12 mm; Volume: 0.0000261897 m3
Identity Data - Description long: RAUTITAN SHOWER ASSEMBLY B/U 8"; GTIN: 4007360479459; Mark: 9; PID: 245967-401; Weight: 0
Mechanical - System Classification: Domestic Cold Water,Domestic Hot Water
Phasing - Phase Created: New Construction

# IfcOpeningElement (78)
In: REHAU Starting view
PredefinedType: OPENING
Pset_EnvironmentalImpactIndicators - sets with these values: 2
Name | Description | Reference
Halter O 100:1 | REHAU Bracket O 100, for double connection | REHAU_RAUTITAN_Bracket O 100:REHAU_RAUTITAN_Bracket O 100
Halter O 100:2 | REHAU Bracket O 100, for double connection | REHAU_RAUTITAN_Bracket O 100:REHAU_RAUTITAN_Bracket O 100
Halter O 100:3 | REHAU Bracket O 100, for double connection | REHAU_RAUTITAN_Bracket O 100:REHAU_RAUTITAN_Bracket O 100
Halter O 100:4 | REHAU Bracket O 100, for double connection | REHAU_RAUTITAN_Bracket O 100:REHAU_RAUTITAN_Bracket O 100
Halter O 100:5 | REHAU Bracket O 100, for double connection | REHAU_RAUTITAN_Bracket O 100:REHAU_RAUTITAN_Bracket O 100
Halter O 100:6 | REHAU Bracket O 100, for double connection | REHAU_RAUTITAN_Bracket O 100:REHAU_RAUTITAN_Bracket O 100
Halter O 100:7 | REHAU Bracket O 100, for double connection | REHAU_RAUTITAN_Bracket O 100:REHAU_RAUTITAN_Bracket O 100
Halter O 100:8 | REHAU Bracket O 100, for double connection | REHAU_RAUTITAN_Bracket O 100:REHAU_RAUTITAN_Bracket O 100
Halter O 100:9 | REHAU Bracket O 100, for double connection | REHAU_RAUTITAN_Bracket O 100:REHAU_RAUTITAN_Bracket O 100
Halter O 100:10 | REHAU Bracket O 100, for double connection | REHAU_RAUTITAN_Bracket O 100:REHAU_RAUTITAN_Bracket O 100
Halter O 100:11 | REHAU Bracket O 100, for double connection | REHAU_RAUTITAN_Bracket O 100:REHAU_RAUTITAN_Bracket O 100
Halter O 100:12 | REHAU Bracket O 100, for double connection | REHAU_RAUTITAN_Bracket O 100:REHAU_RAUTITAN_Bracket O 100
Halter O 100:13 | REHAU Bracket O 100, for double connection | REHAU_RAUTITAN_Bracket O 100:REHAU_RAUTITAN_Bracket O 100
Halter O 100:14 | REHAU Bracket O 100, for double connection | REHAU_RAUTITAN_Bracket O 100:REHAU_RAUTITAN_Bracket O 100
Halter O 100:15 | REHAU Bracket O 100, for double connection | REHAU_RAUTITAN_Bracket O 100:REHAU_RAUTITAN_Bracket O 100
Halter O 100:16 | REHAU Bracket O 100, for double connection | REHAU_RAUTITAN_Bracket O 100:REHAU_RAUTITAN_Bracket O 100
Halter O 100:17 | REHAU Bracket O 100, for double connection | REHAU_RAUTITAN_Bracket O 100:REHAU_RAUTITAN_Bracket O 100
Halter O 100:18 | REHAU Bracket O 100, for double connection | REHAU_RAUTITAN_Bracket O 100:REHAU_RAUTITAN_Bracket O 100
Halter O 100:19 | REHAU Bracket O 100, for double connection | REHAU_RAUTITAN_Bracket O 100:REHAU_RAUTITAN_Bracket O 100
Halter O 100:20 | REHAU Bracket O 100, for double connection | REHAU_RAUTITAN_Bracket O 100:REHAU_RAUTITAN_Bracket O 100
Halter O 100:21 | REHAU Bracket O 100, for double connection | REHAU_RAUTITAN_Bracket O 100:REHAU_RAUTITAN_Bracket O 100
Halter O 100:22 | REHAU Bracket O 100, for double connection | REHAU_RAUTITAN_Bracket O 100:REHAU_RAUTITAN_Bracket O 100
Halter O 100:23 | REHAU Bracket O 100, for double connection | REHAU_RAUTITAN_Bracket O 100:REHAU_RAUTITAN_Bracket O 100
Halter O 100:24 | REHAU Bracket O 100, for double connection | REHAU_RAUTITAN_Bracket O 100:REHAU_RAUTITAN_Bracket O 100
Halter O 100:25 | REHAU Bracket O 100, for double connection | REHAU_RAUTITAN_Bracket O 100:REHAU_RAUTITAN_Bracket O 100
Halter O 100:26 | REHAU Bracket O 100, for double connection | REHAU_RAUTITAN_Bracket O 100:REHAU_RAUTITAN_Bracket O 100
Halter O 100:27 | REHAU Bracket O 100, for double connection | REHAU_RAUTITAN_Bracket O 100:REHAU_RAUTITAN_Bracket O 100
Halter O 100:28 | REHAU Bracket O 100, for double connection | REHAU_RAUTITAN_Bracket O 100:REHAU_RAUTITAN_Bracket O 100
Halter O 100:29 | REHAU Bracket O 100, for double connection | REHAU_RAUTITAN_Bracket O 100:REHAU_RAUTITAN_Bracket O 100
Halter O 100:30 | REHAU Bracket O 100, for double connection | REHAU_RAUTITAN_Bracket O 100:REHAU_RAUTITAN_Bracket O 100
Halter O 100:31 | REHAU Bracket O 100, for double connection | REHAU_RAUTITAN_Bracket O 100:REHAU_RAUTITAN_Bracket O 100
Halter O 100:32 | REHAU Bracket O 100, for double connection | REHAU_RAUTITAN_Bracket O 100:REHAU_RAUTITAN_Bracket O 100
Halter O 100:33 | REHAU Bracket O 100, for double connection | REHAU_RAUTITAN_Bracket O 100:REHAU_RAUTITAN_Bracket O 100
Halter O 75/150:1 | REHAU Bracket O 75/150, for double connection | REHAU_RAUTITAN_Bracket O 75 150:REHAU_RAUTITAN_Bracket O 75 150
Halter O 75/150:2 | REHAU Bracket O 75/150, for double connection | REHAU_RAUTITAN_Bracket O 75 150:REHAU_RAUTITAN_Bracket O 75 150
Halter O 75/150:3 | REHAU Bracket O 75/150, for double connection | REHAU_RAUTITAN_Bracket O 75 150:REHAU_RAUTITAN_Bracket O 75 150
Halter O 75/150:4 | REHAU Bracket O 75/150, for double connection | REHAU_RAUTITAN_Bracket O 75 150:REHAU_RAUTITAN_Bracket O 75 150
Halter O 75/150:5 | REHAU Bracket O 75/150, for double connection | REHAU_RAUTITAN_Bracket O 75 150:REHAU_RAUTITAN_Bracket O 75 150
Halter O 75/150:6 | REHAU Bracket O 75/150, for double connection | REHAU_RAUTITAN_Bracket O 75 150:REHAU_RAUTITAN_Bracket O 75 150
Halter O 75/150:7 | REHAU Bracket O 75/150, for double connection | REHAU_RAUTITAN_Bracket O 75 150:REHAU_RAUTITAN_Bracket O 75 150
Halter O 75/150:8 | REHAU Bracket O 75/150, for double connection | REHAU_RAUTITAN_Bracket O 75 150:REHAU_RAUTITAN_Bracket O 75 150
Halter O 75/150:9 | REHAU Bracket O 75/150, for double connection | REHAU_RAUTITAN_Bracket O 75 150:REHAU_RAUTITAN_Bracket O 75 150
Halter O 75/150:10 | REHAU Bracket O 75/150, for double connection | REHAU_RAUTITAN_Bracket O 75 150:REHAU_RAUTITAN_Bracket O 75 150
Halter O 75/150:11 | REHAU Bracket O 75/150, for double connection | REHAU_RAUTITAN_Bracket O 75 150:REHAU_RAUTITAN_Bracket O 75 150
Halter O 75/150:12 | REHAU Bracket O 75/150, for double connection | REHAU_RAUTITAN_Bracket O 75 150:REHAU_RAUTITAN_Bracket O 75 150
Halter O 75/150:13 | REHAU Bracket O 75/150, for double connection | REHAU_RAUTITAN_Bracket O 75 150:REHAU_RAUTITAN_Bracket O 75 150
Halter O 75/150:14 | REHAU Bracket O 75/150, for double connection | REHAU_RAUTITAN_Bracket O 75 150:REHAU_RAUTITAN_Bracket O 75 150
Halter O 75/150:15 | REHAU Bracket O 75/150, for double connection | REHAU_RAUTITAN_Bracket O 75 150:REHAU_RAUTITAN_Bracket O 75 150
Halter O 75/150:16 | REHAU Bracket O 75/150, for double connection | REHAU_RAUTITAN_Bracket O 75 150:REHAU_RAUTITAN_Bracket O 75 150
Halter O 75/150:17 | REHAU Bracket O 75/150, for double connection | REHAU_RAUTITAN_Bracket O 75 150:REHAU_RAUTITAN_Bracket O 75 150
Halter O 75/150:18 | REHAU Bracket O 75/150, for double connection | REHAU_RAUTITAN_Bracket O 75 150:REHAU_RAUTITAN_Bracket O 75 150
Halter O 75/150:19 | REHAU Bracket O 75/150, for double connection | REHAU_RAUTITAN_Bracket O 75 150:REHAU_RAUTITAN_Bracket O 75 150
Halter O 75/150:20 | REHAU Bracket O 75/150, for double connection | REHAU_RAUTITAN_Bracket O 75 150:REHAU_RAUTITAN_Bracket O 75 150
Halter O 75/150:21 | REHAU Bracket O 75/150, for double connection | REHAU_RAUTITAN_Bracket O 75 150:REHAU_RAUTITAN_Bracket O 75 150
Halter O 75/150:22 | REHAU Bracket O 75/150, for double connection | REHAU_RAUTITAN_Bracket O 75 150:REHAU_RAUTITAN_Bracket O 75 150
Halter O 75/150:23 | REHAU Bracket O 75/150, for double connection | REHAU_RAUTITAN_Bracket O 75 150:REHAU_RAUTITAN_Bracket O 75 150
Halter O 75/150:24 | REHAU Bracket O 75/150, for double connection | REHAU_RAUTITAN_Bracket O 75 150:REHAU_RAUTITAN_Bracket O 75 150
Halter O 75/150:25 | REHAU Bracket O 75/150, for double connection | REHAU_RAUTITAN_Bracket O 75 150:REHAU_RAUTITAN_Bracket O 75 150
Halter O 75/150:26 | REHAU Bracket O 75/150, for double connection | REHAU_RAUTITAN_Bracket O 75 150:REHAU_RAUTITAN_Bracket O 75 150
Halter O 75/150:27 | REHAU Bracket O 75/150, for double connection | REHAU_RAUTITAN_Bracket O 75 150:REHAU_RAUTITAN_Bracket O 75 150
Halter O 75/150:28 | REHAU Bracket O 75/150, for double connection | REHAU_RAUTITAN_Bracket O 75 150:REHAU_RAUTITAN_Bracket O 75 150
Halter O 75/150:29 | REHAU Bracket O 75/150, for double connection | REHAU_RAUTITAN_Bracket O 75 150:REHAU_RAUTITAN_Bracket O 75 150
Halter O 75/150:30 | REHAU Bracket O 75/150, for double connection | REHAU_RAUTITAN_Bracket O 75 150:REHAU_RAUTITAN_Bracket O 75 150
Halter O 75/150:31 | REHAU Bracket O 75/150, for double connection | REHAU_RAUTITAN_Bracket O 75 150:REHAU_RAUTITAN_Bracket O 75 150
Halter O 75/150:32 | REHAU Bracket O 75/150, for double connection | REHAU_RAUTITAN_Bracket O 75 150:REHAU_RAUTITAN_Bracket O 75 150
Halter O 75/150:33 | REHAU Bracket O 75/150, for double connection | REHAU_RAUTITAN_Bracket O 75 150:REHAU_RAUTITAN_Bracket O 75 150
Halter O 75/150:34 | REHAU Bracket O 75/150, for double connection | REHAU_RAUTITAN_Bracket O 75 150:REHAU_RAUTITAN_Bracket O 75 150
Halter O 75/150:35 | REHAU Bracket O 75/150, for double connection | REHAU_RAUTITAN_Bracket O 75 150:REHAU_RAUTITAN_Bracket O 75 150
Halter O 75/150:36 | REHAU Bracket O 75/150, for double connection | REHAU_RAUTITAN_Bracket O 75 150:REHAU_RAUTITAN_Bracket O 75 150
Halter O 75/150:37 | REHAU Bracket O 75/150, for double connection | REHAU_RAUTITAN_Bracket O 75 150:REHAU_RAUTITAN_Bracket O 75 150
Halter O 75/150:38 | REHAU Bracket O 75/150, for double connection | REHAU_RAUTITAN_Bracket O 75 150:REHAU_RAUTITAN_Bracket O 75 150
Halter O 75/150:39 | REHAU Bracket O 75/150, for double connection | REHAU_RAUTITAN_Bracket O 75 150:REHAU_RAUTITAN_Bracket O 75 150
Halter O 75/150:40 | REHAU Bracket O 75/150, for double connection | REHAU_RAUTITAN_Bracket O 75 150:REHAU_RAUTITAN_Bracket O 75 150
Halter O 75/150:41 | REHAU Bracket O 75/150, for double connection | REHAU_RAUTITAN_Bracket O 75 150:REHAU_RAUTITAN_Bracket O 75 150
Halter O 75/150:42 | REHAU Bracket O 75/150, for double connection | REHAU_RAUTITAN_Bracket O 75 150:REHAU_RAUTITAN_Bracket O 75 150
Halter O 75/150:43 | REHAU Bracket O 75/150, for double connection | REHAU_RAUTITAN_Bracket O 75 150:REHAU_RAUTITAN_Bracket O 75 150
Halter O 75/150:44 | REHAU Bracket O 75/150, for double connection | REHAU_RAUTITAN_Bracket O 75 150:REHAU_RAUTITAN_Bracket O 75 150
Halter O 75/150:45 | REHAU Bracket O 75/150, for double connection | REHAU_RAUTITAN_Bracket O 75 150:REHAU_RAUTITAN_Bracket O 75 150

# IfcPipeFitting: RAUTITAN_Adapter_external_thread LX+G_LX:RTI A external LX+G_LX DE (10)
In: REHAU Starting view
Type - Material: Brass
Type - Other - Category: Pipe Fittings; Family Name: RAUTITAN_Adapter_external_thread LX+G_LX; T1: RTI Adapter external thread LX+G_LX; T2: RTI Adapter external thread LX+G_LX DN1+2
Type - Constraints - Default Elevation: 0 mm
Type - Data - Language: Description de; Region Check: Check DE; Region PID: PID DE
Type - Identity Data - Assembly Code: D2090800; Manufacturer: REHAU; Model: RAUTITAN; REHAU Info: 2024.11.21-419114-419114; Type Name: RTI A external LX+G_LX DE
Type - Pset_ManufacturerTypeInformation - Manufacturer: REHAU
Classification: D2090800 (Uniformat)
Pset_EnvironmentalImpactIndicators - Reference: RAUTITAN_Adapter_external_thread LX+G_LX:RTI A external LX+G_LX DE; sets with these values: 2
Other - IsCustom: no; Family: RAUTITAN_Adapter_external_thread LX+G_LX; Family and Type: RAUTITAN_Adapter_external_thread LX+G_LX: RTI A external LX+G_LX DE; Type: RTI A external LX+G_LX DE; Type Id: 1089349
Constraints - Elevation from Level: 0 mm; Level: REHAU Starting view
Data - PID Check: 1 mm
Dimensions - Area: 0.00465431 m2
Graphics - Use Annotation Scale: no
Identity Data - ETIM Class code: EC003025
Mechanical - System Classification: Undefined
Phasing - Phase Created: New Construction
Insulation - Insulation Thickness: 0 mm
Name (RAUTITAN_Adapter_external_thread LX+G_LX:RTI A external LX+G_LX DE:...) | A (deg) | DN1 (mm) | DN2 (mm) | ID1 (mm) | ID2 (mm) | Maximum Size (mm) | Minimum Size (mm) | Size = Overall Size | SWL (mm) | SWL/2 (mm) | Volume (m3) | Z1 (mm) | Z2 (mm) | Description long | GTIN | PID | Weight
1443947 | 60 | 20 | 15 | 15.2 | 15 | 20 | 15 | 20 mmø-15 mmø | 22 | 11 | 0.00001245 | 3.54 | 11.17 | REHAU Übergang RAUTITAN LX +G 25 - R 1/2 | 4007360543273 | 13129961001 | 0.089
1443949 | 60 | 20 | 20 | 15.2 | 19 | 20 | 20 | 20 mmø-20 mmø | 22 | 11 | 0.0000147651 | 3.54 | 13.68 | REHAU Übergang RAUTITAN LX +G 25 - R 3/4 | 4007360543280 | 13129971001 | 0.105
1443951 | 45 | 20 | 25 | 15.2 | 25.5 | 25 | 20 | 25 mmø-20 mmø | 34 | 17 | 0.0000178754 | 9.72 | 6.7 | REHAU Übergang RAUTITAN LX +G 25 - R 1 | 4007360543297 | 13129981001 | 0.17
1443953 | 60 | 25 | 20 | 20 | 19 | 25 | 20 | 25 mmø-20 mmø | 27 | 13.5 | 0.0000218589 | 4.33 | 12.65 | REHAU Übergang RAUTITAN LX +G 32 - R 3/4 | 4007360543303 | 13129991001 | 0.154
1443955 | 60 | 25 | 25 | 20 | 25.5 | 25 | 25 | 25 mmø-25 mmø | 27 | 13.5 | 0.0000240241 | 4.33 | 14.19 | REHAU Übergang RAUTITAN LX +G 32 - R 1 | 4007360543310 | 13130581001 | 0.198
1443957 | 60 | 32 | 32 | 23.5 | 32 | 32 | 32 | 32 mmø-32 mmø | 32 | 16 | 0.0000461137 | 5.5 | 18.17 | REHAU Übergang RAUTITAN LX +G 40 - R 1 1/4 | 4007360543327 | 13130601001 | 0.358
1443959 | 60 | 40 | 40 | 30.5 | 37.5 | 40 | 40 | 40 mmø-40 mmø | 40 | 20 | 0.0000679767 | 5.25 | 18.29 | REHAU Übergang SDR 7,4 LX 50 - R 1 1/2 | 4007360459710 | 11681111001 | 0.516
1443961 | 60 | 50 | 50 | 39.5 | 49.5 | 50 | 50 | 50 mmø-50 mmø | 49 | 24.5 | 0.000110526 | 5.77 | 19.68 | REHAU Übergang SDR 7,4 LX 63 - R 2 | 4007360459635 | 11681131001 | 0.831
1444107 | 60 | 15 | 15 | 12.5 | 15 | 15 | 15 | 15 mmø-15 mmø | 18 | 9 | 0.00000872263 | 3.33 | 13.11 | REHAU Übergang RAUTITAN LX +G 20 - R 1/2 | 4007360543259 | 13129941001 | 0.07
1444109 | 60 | 15 | 20 | 12.5 | 19 | 20 | 15 | 20 mmø-15 mmø | 18 | 9 | 0.0000100112 | 3.35 | 13.11 | REHAU Übergang RAUTITAN LX +G 20 - R 3/4 | 4007360543266 | 13129951001 | 0.073

# IfcPipeFitting: RAUTITAN_Adapter_external_thread LX+G_LX:RTI A external LX+G_LX DE (2)
In: REHAU Starting view
Type - Material: Error, Brass
Type - Other - Category: Pipe Fittings; Family Name: RAUTITAN_Adapter_external_thread LX+G_LX; T1: RTI Adapter external thread LX+G_LX; T2: RTI Adapter external thread LX+G_LX DN1+2
Type - Constraints - Default Elevation: 0 mm
Type - Data - Language: Description de; Region Check: Check DE; Region PID: PID DE
Type - Identity Data - Assembly Code: D2090800; Manufacturer: REHAU; Model: RAUTITAN; REHAU Info: 2024.11.21-419114-419114; Type Name: RTI A external LX+G_LX DE
Type - Pset_ManufacturerTypeInformation - Manufacturer: REHAU
Classification: D2090800 (Uniformat)
Pset_EnvironmentalImpactIndicators - Reference: RAUTITAN_Adapter_external_thread LX+G_LX:RTI A external LX+G_LX DE; sets with these values: 2
Other - IsCustom: yes; A: 45 deg; Family: RAUTITAN_Adapter_external_thread LX+G_LX; Family and Type: RAUTITAN_Adapter_external_thread LX+G_LX: RTI A external LX+G_LX DE; Type: RTI A external LX+G_LX DE; Type Id: 1089349
Constraints - Elevation from Level: 0 mm; Level: REHAU Starting view
Data - PID Check: 0 mm
Dimensions - Area: 0.00465431 m2; DN1: 12 mm; ID1: 9.9 mm; Minimum Size: 12 mm; Volume: 0.0000321717 m3; Z1: 8.97 mm
Graphics - Use Annotation Scale: no
Identity Data - ETIM Class code: EC003025; PID: -
Mechanical - System Classification: Undefined
Phasing - Phase Created: New Construction
Insulation - Insulation Thickness: 0 mm
Name (RAUTITAN_Adapter_external_thread LX+G_LX:RTI A external LX+G_LX DE:...) | DN2 (mm) = Maximum Size (mm) | ID2 (mm) | Size = Overall Size | SWL (mm) | SWL/2 (mm) | Z2 (mm) | Description long | GTIN | Weight
1444129 | 15 | 15 | 15 mmø-12 mmø | 21 | 10.5 | 7.72 | REHAU Übergang RAUTITAN LX +G 16 - R 1/2 | 4007360543235 | 0.062
1444131 | 20 | 19 | 20 mmø-12 mmø | 27 | 13.5 | 6.5 | REHAU Übergang RAUTITAN LX +G 16 - R 3/4 | 4007360543242 | 0.07

# IfcPipeFitting: RAUTITAN_Adapter_external_thread:RTI A external DE (14)
In: REHAU Starting view
Type - Material: RAUTITAN RX+
Type - Other - Category: Pipe Fittings; Family Name: RAUTITAN_Adapter_external_thread; T1: RTI Adapter external thread; T2: RTI Adapter external thread DN1+2
Type - Constraints - Default Elevation: 0 mm
Type - Data - Language: Description de; Region Check: Check DE; Region PID: PID DE
Type - Identity Data - Assembly Code: D2090800; Manufacturer: REHAU; Model: RAUTITAN; REHAU Info: 2024.11.21-419114-419114; Type Name: RTI A external DE
Type - Pset_ManufacturerTypeInformation - Manufacturer: REHAU
Classification: D2090800 (Uniformat)
Pset_EnvironmentalImpactIndicators - Reference: RAUTITAN_Adapter_external_thread:RTI A external DE; sets with these values: 2
Other - IsCustom: no; Family: RAUTITAN_Adapter_external_thread; Family and Type: RAUTITAN_Adapter_external_thread: RTI A external DE; Type: RTI A external DE; Type Id: 1089350
Constraints - Elevation from Level: 0 mm; Level: REHAU Starting view
Data - PID Check: 1 mm
Dimensions - Area: 0.00465431 m2
Graphics - Use Annotation Scale: no
Identity Data - ETIM Class code: EC003025
Mechanical - System Classification: Undefined
Phasing - Phase Created: New Construction
Insulation - Insulation Thickness: 0 mm
