Properties of the parts of a building model (IFC4), part 7 of 10

# IfcPipeFitting: REHAU_RAUTITAN_Pipe bend with former:REHAU_RAUTITAN_Pipe bend with former (8)
Name (REHAU_RAUTITAN_Pipe bend with former:REHAU_RAUTITAN_Pipe bend with former:...) | Nominal Diameter (mm) = DN1 (mm) = DN2 (mm) = Maximum Size (mm) = Minimum Size (mm) | Angle (deg) = REH_ANGLE_CHECK (deg) | a (mm) | Do (mm) | ID (mm) | r (mm) | r2 (mm) | Size = Overall Size | Volume (m3) | REH_DIMENSION
1447698 | 12 | 90 | 48 | 16 | 11.6 | 48 | 8 | 12 mmø-12 mmø | 0.0000113876 | DN 12/12,90°
1447702 | 15 | 90 | 60 | 20 | 14.4 | 60 | 10 | 15 mmø-15 mmø | 0.000020916 | 20, 90°
1447706 | 20 | 90 | 75 | 25 | 18 | 75 | 12.5 | 20 mmø-20 mmø | 0.0000481798 | 25, 90°
1447710 | 25 | 90 | 128 | 32 | 23.2 | 128 | 16 | 25 mmø-25 mmø | 0.000109515 | 32, 90°
1447714 | 12 | 45 | 20 | 16 | 11.6 | 48.2843 | 8 | 12 mmø-12 mmø | 0.00000837199 | 16, 45°
1447718 | 15 | 45 | 25 | 20 | 14.4 | 60.3553 | 10 | 15 mmø-15 mmø | 0.0000149364 | 20, 45°
1447722 | 20 | 45 | 31 | 25 | 18 | 74.8406 | 12.5 | 20 mmø-20 mmø | 0.0000363714 | 25, 45°
1447726 | 25 | 45 | 40 | 32 | 23.2 | 96.5685 | 16 | 25 mmø-25 mmø | 0.0000662129 | 32, 45°

# IfcPipeFitting: REHAU_RAUTITAN_T-piece RX+ stabil, outlet with internal thread:REHAU_RAUTITAN_T-piece RX+ stabil, outlet with internal thread (4)
In: REHAU Starting view
Type - Material: RX
Type - Other - Category: Pipe Fittings; Family Name: REHAU_RAUTITAN_T-piece RX+ stabil, outlet with internal thread
Type - Constraints - Default Elevation: 0 mm
Type - Identity Data - ETIM_CLASS: EC003025; ETIM_MODELLING_CLASS: MC000017; REH_BIM_SUPPORT: bim@rehau.com; REH_INFO: 2023.01.19-416508-416508; REH_PRICE_LIST: DE_2023; REH_PRODUCT_PICTURE: https://static.rehau.com/bim/images/1000/jpg/ M-103171.jpg; Type Name: REHAU_RAUTITAN_T-piece RX+ stabil, outlet with internal thread
Type - Materials and Finishes - REH_MATERIAL: RX
Pset_EnvironmentalImpactIndicators - Reference: REHAU_RAUTITAN_T-piece RX+ stabil, outlet with internal thread:REHAU_RAUTITAN_T-piece RX+ stabil, outlet with internal thread; sets with these values: 2
Other - IsCustom: no; Family: REHAU_RAUTITAN_T-piece RX+ stabil, outlet with internal thread; Family and Type: REHAU_RAUTITAN_T-piece RX+ stabil, outlet with internal thread: REHAU_RAUTITAN_T-piece RX+ stabil, outlet with internal thread; Type: REHAU_RAUTITAN_T-piece RX+ stabil, outlet with internal thread; Type Id: 1089335
Constraints - Elevation from Level: 0 mm; Level: REHAU Starting view
Dimensions - a: 90 deg; REH_ANGLE_CHECK: 90 deg; Area: 0.0041524 m2
Graphics - Use Annotation Scale: no
Identity Data - REH_DESCRIPTION_LANGUAGE: Language : EN
Mechanical - System Classification: Undefined
Phasing - Phase Created: New Construction
Insulation - Insulation Thickness: 0 mm
Name (REHAU_RAUTITAN_T-piece RX+ stabil, outlet with internal thread:REHAU_RAUTITAN_T-piece RX+ stabil, outlet with internal thread:...) | Nominal Diameter 1 (mm) = Nominal Diameter 3 (mm) = DN1 (mm) = DN3 (mm) = Maximum Size (mm) | Nominal Diameter 2 (mm) = DN2 (mm) = Minimum Size (mm) | Do1 (mm) = Do3 (mm) | Dr1 (mm) = Dr2 (mm) = Dr3 (mm) | L1 (mm) = L3 (mm) | L2 (mm) | Size = Overall Size | t1 (mm) = t3 (mm) | Volume (m3) | Z1 (mm) = Z3 (mm) | Z2 (mm) | PID = REH_SUPPLIER_PID | REH_DESCRIPTION_SHORT | REH_DIMENSION | REH_GTIN | REH_NETWEIGHT_G/PC | REH_NOMINAL_DIAMETER
1445066 | 40 | 25 | 50 | 61 | 77 | 40 | 40 mmø-40 mmø-25 mmø | 9 | 0.000129232 | 38 | 27 | 14600251001 | REHAU T-piece RAUTITAN RX+ stabil, 50 - Rp 1 - 50 | 50 - Rp 1 - 50 | 4062178676032 | 910 | DN 40/25/40
1445078 | 50 | 25 | 63 | 74 | 87 | 44 | 50 mmø-50 mmø-25 mmø | 12.5 | 0.000198197 | 41 | 31 | 14600271001 | REHAU T-piece RAUTITAN RX+ stabil, 63 - Rp 1 - 63 | 63 - Rp 1 - 63 | 4062178676049 | 1402 | DN 50/25/50
1447317 | 40 | 15 | 50 | 61 | 69.5 | 36 | 40 mmø-40 mmø-15 mmø | 9 | 0.000107882 | 30.5 | 26 | 14600241001 | REHAU T-piece RAUTITAN RX+ stabil, 50 - Rp 1/2 - 50 | 50 - Rp 1/2 - 50 | 4062178755492 | 802 | DN 40/15/40
1447323 | 50 | 15 | 63 | 74 | 80 | 44 | 50 mmø-50 mmø-15 mmø | 12.5 | 0.000177693 | 34 | 34 | 14600261001 | REHAU T-piece RAUTITAN RX+ stabil, 63 - Rp 1/2 - 63 | 63 - Rp 1/2 - 63 | 4062178755508 | 1284 | DN 50/15/50

# IfcPipeFitting: REHAU_RAUTITAN_T-piece RX+, outlet with internal thread:REHAU_RAUTITAN_T-piece RX+, outlet with internal thread (6)
In: REHAU Starting view
Type - Material: RX
Type - Other - Category: Pipe Fittings; Family Name: REHAU_RAUTITAN_T-piece RX+, outlet with internal thread
Type - Constraints - Default Elevation: 0 mm
Type - Identity Data - ETIM_CLASS: EC003025; ETIM_MODELLING_CLASS: MC000017; Manufacturer: "REHAU"; REH_BIM_SUPPORT: bim@rehau.com; REH_INFO: 2023.01.17-416508-416508; REH_PRICE_LIST: DE_2022; REH_PRODUCT_PICTURE: https://static.rehau.com/bim/images/1000/jpg/M-52497.jpg; Type Name: REHAU_RAUTITAN_T-piece RX+, outlet with internal thread
Type - Materials and Finishes - REH_MATERIAL: RX
Type - Pset_ManufacturerTypeInformation - Manufacturer: "REHAU"
Pset_EnvironmentalImpactIndicators - Reference: REHAU_RAUTITAN_T-piece RX+, outlet with internal thread:REHAU_RAUTITAN_T-piece RX+, outlet with internal thread; sets with these values: 2
Other - IsCustom: no; Family: REHAU_RAUTITAN_T-piece RX+, outlet with internal thread; Family and Type: REHAU_RAUTITAN_T-piece RX+, outlet with internal thread: REHAU_RAUTITAN_T-piece RX+, outlet with internal thread; Type: REHAU_RAUTITAN_T-piece RX+, outlet with internal thread; Type Id: 1089337
Constraints - Elevation from Level: 0 mm; Level: REHAU Starting view
Dimensions - a: 90 deg; REH_ANGLE_CHECK: 90 deg
Graphics - Use Annotation Scale: no
Identity Data - REH_DESCRIPTION_LANGUAGE: Language : EN
Mechanical - System Classification: Undefined
Phasing - Phase Created: New Construction
Insulation - Insulation Thickness: 0 mm
Name (REHAU_RAUTITAN_T-piece RX+, outlet with internal thread:REHAU_RAUTITAN_T-piece RX+, outlet with internal thread:...) | Nominal Diameter 1 (mm) = DN1 (mm) = Maximum Size (mm) | Nominal Diameter 2 (mm) = DN2 (mm) = Minimum Size (mm) | Nominal Diameter 3 (mm) = DN3 (mm) | Do1 (mm) | Do3 (mm) | Dr1 (mm) | Dr3 (mm) | L1 (mm) | L2 (mm) | L3 (mm) | Size = Overall Size | t1 (mm) | t3 (mm) | Volume (m3) | Z1 (mm) | Z2 (mm) | Z3 (mm) | PID = REH_SUPPLIER_PID | REH_DESCRIPTION_SHORT | REH_DIMENSION | REH_GTIN | REH_NETWEIGHT_G/PC | REH_NOMINAL_DIAMETER
1444940 | 20 | 15 | 20 | 25 | 25 | 33.6 | 33.6 | 51 | 26.16 | 51 | 20 mmø-20 mmø-15 mmø | 4.2 | 4.2 | 0.0000289121 | 24 | 15.15 | 24 | 14564141001 | REHAU T-piece RAUTITAN RX+, 25 - Rp 1/2 - 25 | 25 - Rp 1/2 - 25 | 4061264398285 | 189 | DN 20/15/20
1445084 | 25 | 20 | 20 | 32 | 25 | 39.58 | 33.59 | 60.82 | 29.7 | 55.14 | 25 mmø-20 mmø-20 mmø | 4.95 | 4.2 | 0.0000495085 | 29.16 | 13.7 | 28.14 | 14562981001 | REHAU T-piece RAUTITAN RX+, 32 - Rp 3/4 - 25 | 32 - Rp 3/4 - 25 | 4061264397127 | 277 | DN 25/20/20
1445090 | 25 | 20 | 25 | 32 | 32 | 40 | 40 | 61 | 30 | 61 | 25 mmø-25 mmø-20 mmø | 5 | 5 | 0.0000503671 | 29 | 18 | 29 | 14562971001 | REHAU T-piece RAUTITAN RX+, 32 - Rp 3/4 - 32 | 32 - Rp 3/4 - 32 | 4061264397110 | 327 | DN 25/20/25
1445096 | 32 | 25 | 32 | 40 | 40 | 48.98 | 48.98 | 69 | 34.5 | 69 | 32 mmø-32 mmø-25 mmø | 9 | 9 | 0.000103868 | 37.01 | 20.76 | 37.01 | 14563001001 | REHAU T-piece RAUTITAN RX+, 40 - Rp 1 - 40 | 40 - Rp 1 - 40 | 4061264397141 | 645 | DN 32/25/32
1445102 | 20 | 20 | 20 | 25 | 25 | 33.6 | 33.6 | 55 | 27.06 | 55 | 20 mmø-20 mmø-20 mmø | 4.2 | 4.2 | 0.0000340119 | 28 | 15.08 | 28 | 14562961001 | REHAU T-piece RAUTITAN RX+, 25 - Rp 3/4 - 25 | 25 - Rp 3/4 - 25 | 4061264397103 | 216 | DN 20/20/20
1445108 | 25 | 25 | 25 | 32 | 32 | 40 | 40 | 65 | 33 | 65 | 25 mmø-25 mmø-25 mmø | 5 | 5 | 0.0000626846 | 33 | 18.92 | 33 | 14562991001 | REHAU T-piece RAUTITAN RX+, 32 - Rp 1 - 32 | 32 - Rp 1 - 32 | 4061264397134 | 387 | DN 25/25/25

# IfcPipeFitting: REHAU_RAUTITAN_T-piece_RX+_MeplaFix:REHAU_RAUTITAN_T-piece_RX+_MeplaFix (2)
In: REHAU Starting view
Type - Material: PX, RX
Type - Other - Category: Pipe Fittings; Family Name: REHAU_RAUTITAN_T-piece_RX+_MeplaFix
Type - Constraints - Default Elevation: 0 mm
Type - Identity Data - ETIM_CLASS: EC003025; ETIM_MODELLING_CLASS: N/A; REH_BIM_SUPPORT: bim@rehau.com; REH_INFO: 2023.12.20-419114-419114; REH_PRICE_LIST: DE_2023; REH_PRODUCT_PICTURE: https://static.rehau.com/bim/images/1000/jpg/M-52549.jpg; Type Name: REHAU_RAUTITAN_T-piece_RX+_MeplaFix
Type - Materials and Finishes - REH_MATERIAL: RX
Pset_EnvironmentalImpactIndicators - Reference: REHAU_RAUTITAN_T-piece_RX+_MeplaFix:REHAU_RAUTITAN_T-piece_RX+_MeplaFix; sets with these values: 2
Other - b: 1.97 mm; d: 12.7 mm; Family: REHAU_RAUTITAN_T-piece_RX+_MeplaFix; Family and Type: REHAU_RAUTITAN_T-piece_RX+_MeplaFix: REHAU_RAUTITAN_T-piece_RX+_MeplaFix; Type: REHAU_RAUTITAN_T-piece_RX+_MeplaFix; Type Id: 1089339
Constraints - Elevation from Level: 0 mm; Level: REHAU Starting view
Construction - Nominal Diameter 2: 13 mm
Dimensions - Area: 0.0041524 m2; DN2: 13 mm; Do2: 13 mm; Dr2: 21.7 mm
Graphics - Use Annotation Scale: no
Identity Data - REH_DESCRIPTION_LANGUAGE: Language : EN
Mechanical - System Classification: Hydronic Supply
Phasing - Phase Created: New Construction
Insulation - Insulation Thickness: 0 mm
Name (REHAU_RAUTITAN_T-piece_RX+_MeplaFix:REHAU_RAUTITAN_T-piece_RX+_MeplaFix:...) | c (mm) | Nominal Diameter 1 (mm) = Nominal Diameter 3 (mm) = DN1 (mm) = DN3 (mm) | Do1 (mm) = Do3 (mm) | Dr1 (mm) = Dr3 (mm) | L1 (mm) = L3 (mm) | L2 (mm) | Maximum Size (mm) | Minimum Size (mm) | Size = Overall Size | t1 (mm) = t3 (mm) | t2 (mm) | Volume (m3) | Z1 (mm) = Z3 (mm) | Z2 (mm) | PID = REH_SUPPLIER_PID | REH_DESCRIPTION_SHORT | REH_DIMENSION | REH_GTIN | REH_NETWEIGHT_G/PC | REH_NOMINAL_DIAMETER
1441482 | 28.1 | 15 | 20 | 26.5 | 45.3 | 40.6 | 15 | 13 | 15 mmø-15 mmø-13 mmø | 4.3 | 2.6 | 0.0000299965 | 25.8 | 19.6 | 14564121001 | REHAU RAUTITAN T-piece RX+ 20 - MeplaFix - 20 | 20 - MeplaFix - 20 | 4061264398261 | 108 | DN 15/MeplaFix/15
1442377 | 26.6 | 12 | 16 | 22.5 | 40.8 | 39.1 | 13 | 12 | 13 mmø-12 mmø-12 mmø | 3.8 | 2.8 | 0.0000253619 | 25.3 | 18.1 | 14564071001 | REHAU RAUTITAN T-piece RX+ 16 - MeplaFix - 16 | 16 - MeplaFix - 16 | 4061264398216 | 93 | DN 12/MeplaFix/12

# IfcPipeFitting: REHAU_RAUTITAN_T-piece_RX+_with external thread:REHAU_RAUTITAN_T-piece_RX+_with external thread (3)
In: REHAU Starting view
Type - Material: RX
Type - Other - Category: Pipe Fittings; Family Name: REHAU_RAUTITAN_T-piece_RX+_with external thread
Type - Constraints - Default Elevation: 0 mm
Type - Identity Data - ETIM_CLASS: EC003025; ETIM_MODELLING_CLASS: MC000017; Manufacturer: REHAU; REH_PRICE_LIST: DE_2022; REH_PRODUCT_PICTURE: https://static.rehau.com/bim/images/1000/jpg/M-52543.jpg; Type Name: REHAU_RAUTITAN_T-piece_RX+_with external thread
Type - Materials and Finishes - REH_MATERIAL: RX
Type - Pset_ManufacturerTypeInformation - Manufacturer: REHAU
Pset_EnvironmentalImpactIndicators - Reference: REHAU_RAUTITAN_T-piece_RX+_with external thread:REHAU_RAUTITAN_T-piece_RX+_with external thread; sets with these values: 2
Other - Family: REHAU_RAUTITAN_T-piece_RX+_with external thread; Family and Type: REHAU_RAUTITAN_T-piece_RX+_with external thread: REHAU_RAUTITAN_T-piece_RX+_with external thread; Type: REHAU_RAUTITAN_T-piece_RX+_with external thread; Type Id: 1089341
Constraints - Elevation from Level: 0 mm; Level: REHAU Starting view
Dimensions - a: 90 deg; REH_ANGLE_CHECK: 90 deg; Area: 0.0041524 m2; t1: 3.8 mm; t2: 3.8 mm; t3: 7 mm
Graphics - Use Annotation Scale: no
Identity Data - REH_DESCRIPTION_LANGUAGE: Language : EN; REH_INFO: 2022.12.13-416508-416508
Mechanical - System Classification: Undefined
Phasing - Phase Created: New Construction
Insulation - Insulation Thickness: 0 mm
Name (REHAU_RAUTITAN_T-piece_RX+_with external thread:REHAU_RAUTITAN_T-piece_RX+_with external thread:...) | Nominal Diameter 1 (mm) = Nominal Diameter 2 (mm) = DN1 (mm) = DN2 (mm) = Minimum Size (mm) | Nominal Diameter 3 (mm) = DN3 (mm) = Maximum Size (mm) | Do1 (mm) = Do2 (mm) | Dr1 (mm) = Dr2 (mm) | L1 (mm) | L2 (mm) | L3 (mm) | Size = Overall Size | SW3 (mm) | Volume (m3) | Z1 (mm) | Z2 (mm) | Z3 (mm) | REH_NETWEIGHT_G/PC | PID = REH_SUPPLIER_PID | REH_DESCRIPTION_SHORT | REH_DIMENSION | REH_GTIN | REH_NOMINAL_DIAMETER
1444946 | 15 | 20 | 20 | 26.5 | 44.65 | 44.8 | 44.65 | 20 mmø-15 mmø-15 mmø | 27 | 0.0000214264 | 25.15 | 25.3 | 30.15 | 188 | 14564021001 | REHAU T-piece RAUTITAN RX+ 20 - 20 - R 3/4 | 20 - 20 - R 3/4 | 4061264398162 | DN 15/15/15
1445114 | 15 | 15 | 20 | 26.5 | 44.8 | 44.8 | 43.2 | 15 mmø-15 mmø-15 mmø | 22 | 0.0000195785 | 25.3 | 25.3 | 30 | 171 | 14564011001 | REHAU T-piece RAUTITAN RX+ 20 - 20 - R 1/2 | 20 - 20 - R 1/2 | 4061264398155 | DN 15/15/15
1445120 | 12 | 15 | 16 | 22.5 | 40.28 | 40 | 40.24 | 15 mmø-12 mmø-12 mmø | 22 | 0.0000152283 | 24.78 | 24.5 | 27 | 135 | 14564001001 | REHAU T-piece RAUTITAN RX+ 16 - 16 - R 1/2 | 16 - 16 - R 1/2 | 4061264398148 | DN 12/12/15

# IfcPipeFitting: REHAU_RAUTITAN_Wall-T-piece RX+, outlet with internal thread:REHAU_RAUTITAN_Wall-T-piece RX+, outlet with internal thread (3)
In: REHAU Starting view
Type - Material: RX
Type - Other - Category: Pipe Fittings; Family Name: REHAU_RAUTITAN_Wall-T-piece RX+, outlet with internal thread
Type - Constraints - Default Elevation: 0 mm
Type - Identity Data - ETIM_CLASS: EC003025; ETIM_MODELLING_CLASS: MC000017; Manufacturer: REHAU; REH_INFO: 2022.07.04-416508-416508; REH_PRICE_LIST: DE_2022; REH_PRODUCT_PICTURE: https://static.rehau.com/bim/images/1000/jpg/M-53783.jpg; Type Name: REHAU_RAUTITAN_Wall-T-piece RX+, outlet with internal thread
Type - Materials and Finishes - REH_MATERIAL: RX
Type - Pset_ManufacturerTypeInformation - Manufacturer: REHAU
Pset_EnvironmentalImpactIndicators - Reference: REHAU_RAUTITAN_Wall-T-piece RX+, outlet with internal thread:REHAU_RAUTITAN_Wall-T-piece RX+, outlet with internal thread; sets with these values: 2
Other - IsCustom: no; Family: REHAU_RAUTITAN_Wall-T-piece RX+, outlet with internal thread; Family and Type: REHAU_RAUTITAN_Wall-T-piece RX+, outlet with internal thread: REHAU_RAUTITAN_Wall-T-piece RX+, outlet with internal thread; Type: REHAU_RAUTITAN_Wall-T-piece RX+, outlet with internal thread; Type Id: 1089343
Constraints - Elevation from Level: 0 mm; Level: REHAU Starting view
Construction - Nominal Diameter 2: 15 mm
Dimensions - a: 90 deg; REH_ANGLE_CHECK: 90 deg; Area: 0.0041524 m2; DN2: 15 mm; Maximum Size: 15 mm
Graphics - Use Annotation Scale: no
Identity Data - REH_DESCRIPTION_LANGUAGE: Language : EN
Mechanical - System Classification: Undefined
Phasing - Phase Created: New Construction
Insulation - Insulation Thickness: 0 mm
Name (REHAU_RAUTITAN_Wall-T-piece RX+, outlet with internal thread:REHAU_RAUTITAN_Wall-T-piece RX+, outlet with internal thread:...) | Nominal Diameter 1 (mm) = DN1 (mm) | Nominal Diameter 3 (mm) = DN3 (mm) = Minimum Size (mm) | Do1 (mm) | Do3 (mm) | Dr1 (mm) | Dr3 (mm) | L1 (mm) | L2 (mm) | L3 (mm) | Size = Overall Size | t1 (mm) = t3 (mm) | Volume (m3) | Z1 (mm) | Z2 (mm) | Z3 (mm) | PID = REH_SUPPLIER_PID | REH_DESCRIPTION_SHORT | REH_DIMENSION | REH_GTIN | REH_NETWEIGHT_G/PC | REH_NOMINAL_DIAMETER
1444952 | 12 | 12 | 16 | 16 | 22.5 | 22.5 | 46.65 | 25.8 | 46.65 | 15 mmø-12 mmø-12 mmø | 3.3 | 0.0000185907 | 31.15 | 14.86 | 31.15 | 14562911001 | REHAU Wall-mounted T-piece RAUTITAN RX+, 16 - Rp 1/2 - 16 | DN 12/15/12 | 4061264397059 | 154 | 16 / Rp 1/2 / 16
1445126 | 15 | 12 | 20 | 16 | 22.68 | 26.68 | 46.82 | 23.75 | 51.31 | 15 mmø-15 mmø-12 mmø | 3.8 | 0.0000223546 | 31.32 | 9.5 | 31.81 | 14562931001 | REHAU Wall-mounted T-piece RAUTITAN RX+, 20 - Rp 1/2 - 16 | DN 15/15/12 | 4061264397073 | 180 | 20 / Rp 1/2 / 16
1445132 | 15 | 15 | 20 | 20 | 26.5 | 26.5 | 49.65 | 23.75 | 49.65 | 15 mmø-15 mmø-15 mmø | 3.8 | 0.0000215793 | 30.15 | 12.94 | 30.15 | 14562941001 | REHAU Wall-mounted T-piece RAUTITAN RX+, 20 - Rp 1/2 - 20 | DN 15/15/15 | 4061264397080 | 177 | 20 / Rp 1/2 / 20

# IfcPipeFitting: Sleeve:LX 7,4 (197)
In: REHAU Starting view
Type - Material: Br
Type - Other - Category: Pipe Fittings; Family Name: Sleeve
Type - Constraints - Default Elevation: 0 mm
Type - Identity Data - Cost: 0; Description: LX 7,4; Manufacturer: REHAU; Model: LX 7,4; REHAU Info: 14.02.2024-420668-420668; Type Name: LX 7,4
Type - Materials and Finishes - Mat. Sleeve: Br
Type - Pset_ManufacturerTypeInformation - Manufacturer: REHAU
Pset_EnvironmentalImpactIndicators - Reference: Sleeve:LX 7,4; sets with these values: 2
Other - IsCustom: no; Family: Sleeve; Family and Type: Sleeve: LX 7,4; Type: LX 7,4; Type Id: 986514; T1: Sleeve DN
Constraints - Elevation from Level: 0 mm; Level: REHAU Starting view; Moves With Nearby Elements: no
Data - Language: Description en; Language Tender Text: Tender Text en; PID Check: 1 mm; Region Check: Check DE; Region PID: PID DE; Region URL: Product URL DE
Dimensions - Area: 0.00262625 m2
Identity Data - Sorting: 0; ETIM Class: EC011668; ETIM Group: EG015540; ETIM Name: Accessories/spare parts for fittings; Tender text: -
Phasing - Phase Created: New Construction
Insulation - Insulation Thickness: 0 mm
Name (Sleeve:LX 7,4:...) | DN1 (mm) | L1 (mm) | Volume (m3) | Description long | GTIN | PID | Product Group | Product URL | Weight
986611 | 15 | 25 | 0.00000393937 | REHAU Compression sleeve RAUT. MX/LX 20 | 4007360031060 | 12596151002 | 1959 | https://oxomi.com/p/3000126/datasheet/-/12596151002 | 0.028
986613 | 15 | 25 | 0.00000393937 | REHAU Compression sleeve RAUT. MX/LX 20 | 4007360031060 | 12596151002 | 1959 | https://oxomi.com/p/3000126/datasheet/-/12596151002 | 0.028
986618 | 20 | 29 | 0.0000058041 | REHAU Compression sleeve RAUT. MX/LX +G 25 | 4007360377519 | 12596251402 | 1960 | https://oxomi.com/p/3000126/datasheet/-/12596251402 | 0.046
986620 | 20 | 29 | 0.0000058041 | REHAU Compression sleeve RAUT. MX/LX +G 25 | 4007360377519 | 12596251402 | 1960 | https://oxomi.com/p/3000126/datasheet/-/12596251402 | 0.046
986624 | 25 | 34 | 0.0000131097 | REHAU Compression sleeve RAUT. MX/LX 32 | 4007360168698 | 11371661001 | 1961 | https://oxomi.com/p/3000126/datasheet/-/11371661001 | 0.096
986626 | 25 | 34 | 0.0000131097 | REHAU Compression sleeve RAUT. MX/LX 32 | 4007360168698 | 11371661001 | 1961 | https://oxomi.com/p/3000126/datasheet/-/11371661001 | 0.096
986630 | 32 | 37 | 0.0000199643 | REHAU Compression sleeve RAUT. MX/LX 40 | 4007360186487 | 11372961001 | 1962 | https://oxomi.com/p/3000126/datasheet/-/11372961001 | 0.162
986632 | 32 | 37 | 0.0000199643 | REHAU Compression sleeve RAUT. MX/LX 40 | 4007360186487 | 11372961001 | 1962 | https://oxomi.com/p/3000126/datasheet/-/11372961001 | 0.162
986636 | 40 | 44 | 0.0000372872 | REHAU Compression sleeve RAUTITAN MX/LX 50 | 4007360031817 | 11397711002 | 1963 | https://oxomi.com/p/3000126/datasheet/-/11397711002 | 0.293
986638 | 40 | 44 | 0.0000372872 | REHAU Compression sleeve RAUTITAN MX/LX 50 | 4007360031817 | 11397711002 | 1963 | https://oxomi.com/p/3000126/datasheet/-/11397711002 | 0.293
986642 | 50 | 53 | 0.0000553035 | REHAU Compression sleeve RAUTITAN MX/LX 63 | 4007360031824 | 11397811002 | 1964 | https://oxomi.com/p/3000126/datasheet/-/11397811002 | 0.439
986644 | 50 | 53 | 0.0000553035 | REHAU Compression sleeve RAUTITAN MX/LX 63 | 4007360031824 | 11397811002 | 1964 | https://oxomi.com/p/3000126/datasheet/-/11397811002 | 0.439
986648 | 50 | 53 | 0.0000553035 | REHAU Compression sleeve RAUTITAN MX/LX 63 | 4007360031824 | 11397811002 | 1964 | https://oxomi.com/p/3000126/datasheet/-/11397811002 | 0.439
986650 | 50 | 53 | 0.0000553035 | REHAU Compression sleeve RAUTITAN MX/LX 63 | 4007360031824 | 11397811002 | 1964 | https://oxomi.com/p/3000126/datasheet/-/11397811002 | 0.439
986652 | 40 | 44 | 0.0000372872 | REHAU Compression sleeve RAUTITAN MX/LX 50 | 4007360031817 | 11397711002 | 1963 | https://oxomi.com/p/3000126/datasheet/-/11397711002 | 0.293
986654 | 40 | 44 | 0.0000372872 | REHAU Compression sleeve RAUTITAN MX/LX 50 | 4007360031817 | 11397711002 | 1963 | https://oxomi.com/p/3000126/datasheet/-/11397711002 | 0.293
986857 | 40 | 44 | 0.0000372872 | REHAU Compression sleeve RAUTITAN MX/LX 50 | 4007360031817 | 11397711002 | 1963 | https://oxomi.com/p/3000126/datasheet/-/11397711002 | 0.293
986859 | 40 | 44 | 0.0000372872 | REHAU Compression sleeve RAUTITAN MX/LX 50 | 4007360031817 | 11397711002 | 1963 | https://oxomi.com/p/3000126/datasheet/-/11397711002 | 0.293
986870 | 50 | 53 | 0.0000553035 | REHAU Compression sleeve RAUTITAN MX/LX 63 | 4007360031824 | 11397811002 | 1964 | https://oxomi.com/p/3000126/datasheet/-/11397811002 | 0.439
986872 | 50 | 53 | 0.0000553035 | REHAU Compression sleeve RAUTITAN MX/LX 63 | 4007360031824 | 11397811002 | 1964 | https://oxomi.com/p/3000126/datasheet/-/11397811002 | 0.439
986996 | 50 | 53 | 0.0000553035 | REHAU Compression sleeve RAUTITAN MX/LX 63 | 4007360031824 | 11397811002 | 1964 | https://oxomi.com/p/3000126/datasheet/-/11397811002 | 0.439
986998 | 50 | 53 | 0.0000553035 | REHAU Compression sleeve RAUTITAN MX/LX 63 | 4007360031824 | 11397811002 | 1964 | https://oxomi.com/p/3000126/datasheet/-/11397811002 | 0.439
987000 | 40 | 44 | 0.0000372872 | REHAU Compression sleeve RAUTITAN MX/LX 50 | 4007360031817 | 11397711002 | 1963 | https://oxomi.com/p/3000126/datasheet/-/11397711002 | 0.293
987002 | 40 | 44 | 0.0000372872 | REHAU Compression sleeve RAUTITAN MX/LX 50 | 4007360031817 | 11397711002 | 1963 | https://oxomi.com/p/3000126/datasheet/-/11397711002 | 0.293
1005944 | 20 | 29 | 0.0000058041 | REHAU Compression sleeve RAUT. MX/LX +G 25 | 4007360377519 | 12596251402 | 1960 | https://oxomi.com/p/3000126/datasheet/-/12596251402 | 0.046
1005946 | 20 | 29 | 0.0000058041 | REHAU Compression sleeve RAUT. MX/LX +G 25 | 4007360377519 | 12596251402 | 1960 | https://oxomi.com/p/3000126/datasheet/-/12596251402 | 0.046
1005948 | 20 | 29 | 0.0000058041 | REHAU Compression sleeve RAUT. MX/LX +G 25 | 4007360377519 | 12596251402 | 1960 | https://oxomi.com/p/3000126/datasheet/-/12596251402 | 0.046
1005951 | 25 | 34 | 0.0000131097 | REHAU Compression sleeve RAUT. MX/LX 32 | 4007360168698 | 11371661001 | 1961 | https://oxomi.com/p/3000126/datasheet/-/11371661001 | 0.096
1005953 | 25 | 34 | 0.0000131097 | REHAU Compression sleeve RAUT. MX/LX 32 | 4007360168698 | 11371661001 | 1961 | https://oxomi.com/p/3000126/datasheet/-/11371661001 | 0.096
1005955 | 25 | 34 | 0.0000131097 | REHAU Compression sleeve RAUT. MX/LX 32 | 4007360168698 | 11371661001 | 1961 | https://oxomi.com/p/3000126/datasheet/-/11371661001 | 0.096
1005958 | 32 | 37 | 0.0000199643 | REHAU Compression sleeve RAUT. MX/LX 40 | 4007360186487 | 11372961001 | 1962 | https://oxomi.com/p/3000126/datasheet/-/11372961001 | 0.162
1005960 | 32 | 37 | 0.0000199643 | REHAU Compression sleeve RAUT. MX/LX 40 | 4007360186487 | 11372961001 | 1962 | https://oxomi.com/p/3000126/datasheet/-/11372961001 | 0.162
1005962 | 32 | 37 | 0.0000199643 | REHAU Compression sleeve RAUT. MX/LX 40 | 4007360186487 | 11372961001 | 1962 | https://oxomi.com/p/3000126/datasheet/-/11372961001 | 0.162
1005966 | 40 | 44 | 0.0000372872 | REHAU Compression sleeve RAUTITAN MX/LX 50 | 4007360031817 | 11397711002 | 1963 | https://oxomi.com/p/3000126/datasheet/-/11397711002 | 0.293
1005968 | 40 | 44 | 0.0000372872 | REHAU Compression sleeve RAUTITAN MX/LX 50 | 4007360031817 | 11397711002 | 1963 | https://oxomi.com/p/3000126/datasheet/-/11397711002 | 0.293
1005970 | 40 | 44 | 0.0000372872 | REHAU Compression sleeve RAUTITAN MX/LX 50 | 4007360031817 | 11397711002 | 1963 | https://oxomi.com/p/3000126/datasheet/-/11397711002 | 0.293
1005974 | 50 | 53 | 0.0000553035 | REHAU Compression sleeve RAUTITAN MX/LX 63 | 4007360031824 | 11397811002 | 1964 | https://oxomi.com/p/3000126/datasheet/-/11397811002 | 0.439
1005976 | 50 | 53 | 0.0000553035 | REHAU Compression sleeve RAUTITAN MX/LX 63 | 4007360031824 | 11397811002 | 1964 | https://oxomi.com/p/3000126/datasheet/-/11397811002 | 0.439
1005978 | 50 | 53 | 0.0000553035 | REHAU Compression sleeve RAUTITAN MX/LX 63 | 4007360031824 | 11397811002 | 1964 | https://oxomi.com/p/3000126/datasheet/-/11397811002 | 0.439
1005982 | 15 | 25 | 0.00000393937 | REHAU Compression sleeve RAUT. MX/LX 20 | 4007360031060 | 12596151002 | 1959 | https://oxomi.com/p/3000126/datasheet/-/12596151002 | 0.028
1005984 | 15 | 25 | 0.00000393937 | REHAU Compression sleeve RAUT. MX/LX 20 | 4007360031060 | 12596151002 | 1959 | https://oxomi.com/p/3000126/datasheet/-/12596151002 | 0.028
1005986 | 15 | 25 | 0.00000393937 | REHAU Compression sleeve RAUT. MX/LX 20 | 4007360031060 | 12596151002 | 1959 | https://oxomi.com/p/3000126/datasheet/-/12596151002 | 0.028
1006000 | 20 | 29 | 0.0000058041 | REHAU Compression sleeve RAUT. MX/LX +G 25 | 4007360377519 | 12596251402 | 1960 | https://oxomi.com/p/3000126/datasheet/-/12596251402 | 0.046
1006002 | 15 | 25 | 0.00000393937 | REHAU Compression sleeve RAUT. MX/LX 20 | 4007360031060 | 12596151002 | 1959 | https://oxomi.com/p/3000126/datasheet/-/12596151002 | 0.028
1006004 | 20 | 29 | 0.0000058041 | REHAU Compression sleeve RAUT. MX/LX +G 25 | 4007360377519 | 12596251402 | 1960 | https://oxomi.com/p/3000126/datasheet/-/12596251402 | 0.046
1006008 | 25 | 34 | 0.0000131097 | REHAU Compression sleeve RAUT. MX/LX 32 | 4007360168698 | 11371661001 | 1961 | https://oxomi.com/p/3000126/datasheet/-/11371661001 | 0.096
1006010 | 20 | 29 | 0.0000058041 | REHAU Compression sleeve RAUT. MX/LX +G 25 | 4007360377519 | 12596251402 | 1960 | https://oxomi.com/p/3000126/datasheet/-/12596251402 | 0.046
1006012 | 25 | 34 | 0.0000131097 | REHAU Compression sleeve RAUT. MX/LX 32 | 4007360168698 | 11371661001 | 1961 | https://oxomi.com/p/3000126/datasheet/-/11371661001 | 0.096
1006015 | 32 | 37 | 0.0000199643 | REHAU Compression sleeve RAUT. MX/LX 40 | 4007360186487 | 11372961001 | 1962 | https://oxomi.com/p/3000126/datasheet/-/11372961001 | 0.162
1006017 | 25 | 34 | 0.0000131097 | REHAU Compression sleeve RAUT. MX/LX 32 | 4007360168698 | 11371661001 | 1961 | https://oxomi.com/p/3000126/datasheet/-/11371661001 | 0.096
1006019 | 32 | 37 | 0.0000199643 | REHAU Compression sleeve RAUT. MX/LX 40 | 4007360186487 | 11372961001 | 1962 | https://oxomi.com/p/3000126/datasheet/-/11372961001 | 0.162
1006023 | 40 | 44 | 0.0000372872 | REHAU Compression sleeve RAUTITAN MX/LX 50 | 4007360031817 | 11397711002 | 1963 | https://oxomi.com/p/3000126/datasheet/-/11397711002 | 0.293
1006025 | 32 | 37 | 0.0000199643 | REHAU Compression sleeve RAUT. MX/LX 40 | 4007360186487 | 11372961001 | 1962 | https://oxomi.com/p/3000126/datasheet/-/11372961001 | 0.162
1006027 | 40 | 44 | 0.0000372872 | REHAU Compression sleeve RAUTITAN MX/LX 50 | 4007360031817 | 11397711002 | 1963 | https://oxomi.com/p/3000126/datasheet/-/11397711002 | 0.293
1006032 | 50 | 53 | 0.0000553035 | REHAU Compression sleeve RAUTITAN MX/LX 63 | 4007360031824 | 11397811002 | 1964 | https://oxomi.com/p/3000126/datasheet/-/11397811002 | 0.439
1006034 | 40 | 44 | 0.0000372872 | REHAU Compression sleeve RAUTITAN MX/LX 50 | 4007360031817 | 11397711002 | 1963 | https://oxomi.com/p/3000126/datasheet/-/11397711002 | 0.293
1006036 | 50 | 53 | 0.0000553035 | REHAU Compression sleeve RAUTITAN MX/LX 63 | 4007360031824 | 11397811002 | 1964 | https://oxomi.com/p/3000126/datasheet/-/11397811002 | 0.439
1006041 | 15 | 25 | 0.00000393937 | REHAU Compression sleeve RAUT. MX/LX 20 | 4007360031060 | 12596151002 | 1959 | https://oxomi.com/p/3000126/datasheet/-/12596151002 | 0.028
1006045 | 15 | 25 | 0.00000393937 | REHAU Compression sleeve RAUT. MX/LX 20 | 4007360031060 | 12596151002 | 1959 | https://oxomi.com/p/3000126/datasheet/-/12596151002 | 0.028
1006050 | 20 | 29 | 0.0000058041 | REHAU Compression sleeve RAUT. MX/LX +G 25 | 4007360377519 | 12596251402 | 1960 | https://oxomi.com/p/3000126/datasheet/-/12596251402 | 0.046
1006054 | 20 | 29 | 0.0000058041 | REHAU Compression sleeve RAUT. MX/LX +G 25 | 4007360377519 | 12596251402 | 1960 | https://oxomi.com/p/3000126/datasheet/-/12596251402 | 0.046
1006058 | 25 | 34 | 0.0000131097 | REHAU Compression sleeve RAUT. MX/LX 32 | 4007360168698 | 11371661001 | 1961 | https://oxomi.com/p/3000126/datasheet/-/11371661001 | 0.096
1006060 | 15 | 25 | 0.00000393937 | REHAU Compression sleeve RAUT. MX/LX 20 | 4007360031060 | 12596151002 | 1959 | https://oxomi.com/p/3000126/datasheet/-/12596151002 | 0.028
1006062 | 25 | 34 | 0.0000131097 | REHAU Compression sleeve RAUT. MX/LX 32 | 4007360168698 | 11371661001 | 1961 | https://oxomi.com/p/3000126/datasheet/-/11371661001 | 0.096
1006066 | 32 | 37 | 0.0000199643 | REHAU Compression sleeve RAUT. MX/LX 40 | 4007360186487 | 11372961001 | 1962 | https://oxomi.com/p/3000126/datasheet/-/11372961001 | 0.162
1006068 | 20 | 29 | 0.0000058041 | REHAU Compression sleeve RAUT. MX/LX +G 25 | 4007360377519 | 12596251402 | 1960 | https://oxomi.com/p/3000126/datasheet/-/12596251402 | 0.046
1006070 | 32 | 37 | 0.0000199643 | REHAU Compression sleeve RAUT. MX/LX 40 | 4007360186487 | 11372961001 | 1962 | https://oxomi.com/p/3000126/datasheet/-/11372961001 | 0.162
1006074 | 40 | 44 | 0.0000372872 | REHAU Compression sleeve RAUTITAN MX/LX 50 | 4007360031817 | 11397711002 | 1963 | https://oxomi.com/p/3000126/datasheet/-/11397711002 | 0.293
1006076 | 25 | 34 | 0.0000131097 | REHAU Compression sleeve RAUT. MX/LX 32 | 4007360168698 | 11371661001 | 1961 | https://oxomi.com/p/3000126/datasheet/-/11371661001 | 0.096
1006078 | 40 | 44 | 0.0000372872 | REHAU Compression sleeve RAUTITAN MX/LX 50 | 4007360031817 | 11397711002 | 1963 | https://oxomi.com/p/3000126/datasheet/-/11397711002 | 0.293
1006082 | 50 | 53 | 0.0000553035 | REHAU Compression sleeve RAUTITAN MX/LX 63 | 4007360031824 | 11397811002 | 1964 | https://oxomi.com/p/3000126/datasheet/-/11397811002 | 0.439
1006084 | 25 | 34 | 0.0000131097 | REHAU Compression sleeve RAUT. MX/LX 32 | 4007360168698 | 11371661001 | 1961 | https://oxomi.com/p/3000126/datasheet/-/11371661001 | 0.096
1006086 | 50 | 53 | 0.0000553035 | REHAU Compression sleeve RAUTITAN MX/LX 63 | 4007360031824 | 11397811002 | 1964 | https://oxomi.com/p/3000126/datasheet/-/11397811002 | 0.439
1006091 | 15 | 25 | 0.00000393937 | REHAU Compression sleeve RAUT. MX/LX 20 | 4007360031060 | 12596151002 | 1959 | https://oxomi.com/p/3000126/datasheet/-/12596151002 | 0.028
1006095 | 15 | 25 | 0.00000393937 | REHAU Compression sleeve RAUT. MX/LX 20 | 4007360031060 | 12596151002 | 1959 | https://oxomi.com/p/3000126/datasheet/-/12596151002 | 0.028
1006100 | 40 | 44 | 0.0000372872 | REHAU Compression sleeve RAUTITAN MX/LX 50 | 4007360031817 | 11397711002 | 1963 | https://oxomi.com/p/3000126/datasheet/-/11397711002 | 0.293
1006102 | 20 | 29 | 0.0000058041 | REHAU Compression sleeve RAUT. MX/LX +G 25 | 4007360377519 | 12596251402 | 1960 | https://oxomi.com/p/3000126/datasheet/-/12596251402 | 0.046
1006104 | 40 | 44 | 0.0000372872 | REHAU Compression sleeve RAUTITAN MX/LX 50 | 4007360031817 | 11397711002 | 1963 | https://oxomi.com/p/3000126/datasheet/-/11397711002 | 0.293
1006111 | 15 | 25 | 0.00000393937 | REHAU Compression sleeve RAUT. MX/LX 20 | 4007360031060 | 12596151002 | 1959 | https://oxomi.com/p/3000126/datasheet/-/12596151002 | 0.028
1006118 | 15 | 25 | 0.00000393937 | REHAU Compression sleeve RAUT. MX/LX 20 | 4007360031060 | 12596151002 | 1959 | https://oxomi.com/p/3000126/datasheet/-/12596151002 | 0.028
1006120 | 20 | 29 | 0.0000058041 | REHAU Compression sleeve RAUT. MX/LX +G 25 | 4007360377519 | 12596251402 | 1960 | https://oxomi.com/p/3000126/datasheet/-/12596251402 | 0.046
1006122 | 15 | 25 | 0.00000393937 | REHAU Compression sleeve RAUT. MX/LX 20 | 4007360031060 | 12596151002 | 1959 | https://oxomi.com/p/3000126/datasheet/-/12596151002 | 0.028
1006136 | 20 | 29 | 0.0000058041 | REHAU Compression sleeve RAUT. MX/LX +G 25 | 4007360377519 | 12596251402 | 1960 | https://oxomi.com/p/3000126/datasheet/-/12596251402 | 0.046
1006138 | 15 | 25 | 0.00000393937 | REHAU Compression sleeve RAUT. MX/LX 20 | 4007360031060 | 12596151002 | 1959 | https://oxomi.com/p/3000126/datasheet/-/12596151002 | 0.028
1006140 | 15 | 25 | 0.00000393937 | REHAU Compression sleeve RAUT. MX/LX 20 | 4007360031060 | 12596151002 | 1959 | https://oxomi.com/p/3000126/datasheet/-/12596151002 | 0.028
1006144 | 25 | 34 | 0.0000131097 | REHAU Compression sleeve RAUT. MX/LX 32 | 4007360168698 | 11371661001 | 1961 | https://oxomi.com/p/3000126/datasheet/-/11371661001 | 0.096
1006146 | 20 | 29 | 0.0000058041 | REHAU Compression sleeve RAUT. MX/LX +G 25 | 4007360377519 | 12596251402 | 1960 | https://oxomi.com/p/3000126/datasheet/-/12596251402 | 0.046
1006148 | 20 | 29 | 0.0000058041 | REHAU Compression sleeve RAUT. MX/LX +G 25 | 4007360377519 | 12596251402 | 1960 | https://oxomi.com/p/3000126/datasheet/-/12596251402 | 0.046
1006150 | 32 | 37 | 0.0000199643 | REHAU Compression sleeve RAUT. MX/LX 40 | 4007360186487 | 11372961001 | 1962 | https://oxomi.com/p/3000126/datasheet/-/11372961001 | 0.162
1006152 | 25 | 34 | 0.0000131097 | REHAU Compression sleeve RAUT. MX/LX 32 | 4007360168698 | 11371661001 | 1961 | https://oxomi.com/p/3000126/datasheet/-/11371661001 | 0.096
1006154 | 25 | 34 | 0.0000131097 | REHAU Compression sleeve RAUT. MX/LX 32 | 4007360168698 | 11371661001 | 1961 | https://oxomi.com/p/3000126/datasheet/-/11371661001 | 0.096
1006159 | 15 | 25 | 0.00000393937 | REHAU Compression sleeve RAUT. MX/LX 20 | 4007360031060 | 12596151002 | 1959 | https://oxomi.com/p/3000126/datasheet/-/12596151002 | 0.028
1006177 | 20 | 29 | 0.0000058041 | REHAU Compression sleeve RAUT. MX/LX +G 25 | 4007360377519 | 12596251402 | 1960 | https://oxomi.com/p/3000126/datasheet/-/12596251402 | 0.046
1006179 | 20 | 29 | 0.0000058041 | REHAU Compression sleeve RAUT. MX/LX +G 25 | 4007360377519 | 12596251402 | 1960 | https://oxomi.com/p/3000126/datasheet/-/12596251402 | 0.046
1006181 | 15 | 25 | 0.00000393937 | REHAU Compression sleeve RAUT. MX/LX 20 | 4007360031060 | 12596151002 | 1959 | https://oxomi.com/p/3000126/datasheet/-/12596151002 | 0.028
1006185 | 25 | 34 | 0.0000131097 | REHAU Compression sleeve RAUT. MX/LX 32 | 4007360168698 | 11371661001 | 1961 | https://oxomi.com/p/3000126/datasheet/-/11371661001 | 0.096
1006187 | 25 | 34 | 0.0000131097 | REHAU Compression sleeve RAUT. MX/LX 32 | 4007360168698 | 11371661001 | 1961 | https://oxomi.com/p/3000126/datasheet/-/11371661001 | 0.096
1006189 | 20 | 29 | 0.0000058041 | REHAU Compression sleeve RAUT. MX/LX +G 25 | 4007360377519 | 12596251402 | 1960 | https://oxomi.com/p/3000126/datasheet/-/12596251402 | 0.046
1006194 | 15 | 25 | 0.00000393937 | REHAU Compression sleeve RAUT. MX/LX 20 | 4007360031060 | 12596151002 | 1959 | https://oxomi.com/p/3000126/datasheet/-/12596151002 | 0.028
1006196 | 15 | 25 | 0.00000393937 | REHAU Compression sleeve RAUT. MX/LX 20 | 4007360031060 | 12596151002 | 1959 | https://oxomi.com/p/3000126/datasheet/-/12596151002 | 0.028
1006202 | 40 | 44 | 0.0000372872 | REHAU Compression sleeve RAUTITAN MX/LX 50 | 4007360031817 | 11397711002 | 1963 | https://oxomi.com/p/3000126/datasheet/-/11397711002 | 0.293
1006204 | 25 | 34 | 0.0000131097 | REHAU Compression sleeve RAUT. MX/LX 32 | 4007360168698 | 11371661001 | 1961 | https://oxomi.com/p/3000126/datasheet/-/11371661001 | 0.096
1006206 | 32 | 37 | 0.0000199643 | REHAU Compression sleeve RAUT. MX/LX 40 | 4007360186487 | 11372961001 | 1962 | https://oxomi.com/p/3000126/datasheet/-/11372961001 | 0.162
1006211 | 20 | 29 | 0.0000058041 | REHAU Compression sleeve RAUT. MX/LX +G 25 | 4007360377519 | 12596251402 | 1960 | https://oxomi.com/p/3000126/datasheet/-/12596251402 | 0.046
1006213 | 20 | 29 | 0.0000058041 | REHAU Compression sleeve RAUT. MX/LX +G 25 | 4007360377519 | 12596251402 | 1960 | https://oxomi.com/p/3000126/datasheet/-/12596251402 | 0.046
1006220 | 25 | 34 | 0.0000131097 | REHAU Compression sleeve RAUT. MX/LX 32 | 4007360168698 | 11371661001 | 1961 | https://oxomi.com/p/3000126/datasheet/-/11371661001 | 0.096
1006222 | 15 | 25 | 0.00000393937 | REHAU Compression sleeve RAUT. MX/LX 20 | 4007360031060 | 12596151002 | 1959 | https://oxomi.com/p/3000126/datasheet/-/12596151002 | 0.028
1006224 | 20 | 29 | 0.0000058041 | REHAU Compression sleeve RAUT. MX/LX +G 25 | 4007360377519 | 12596251402 | 1960 | https://oxomi.com/p/3000126/datasheet/-/12596251402 | 0.046
1007448 | 40 | 44 | 0.0000372872 | REHAU Compression sleeve RAUTITAN MX/LX 50 | 4007360031817 | 11397711002 | 1963 | https://oxomi.com/p/3000126/datasheet/-/11397711002 | 0.293
1007450 | 40 | 44 | 0.0000372872 | REHAU Compression sleeve RAUTITAN MX/LX 50 | 4007360031817 | 11397711002 | 1963 | https://oxomi.com/p/3000126/datasheet/-/11397711002 | 0.293
1007452 | 40 | 44 | 0.0000372872 | REHAU Compression sleeve RAUTITAN MX/LX 50 | 4007360031817 | 11397711002 | 1963 | https://oxomi.com/p/3000126/datasheet/-/11397711002 | 0.293
1007454 | 50 | 53 | 0.0000553035 | REHAU Compression sleeve RAUTITAN MX/LX 63 | 4007360031824 | 11397811002 | 1964 | https://oxomi.com/p/3000126/datasheet/-/11397811002 | 0.439
1007456 | 50 | 53 | 0.0000553035 | REHAU Compression sleeve RAUTITAN MX/LX 63 | 4007360031824 | 11397811002 | 1964 | https://oxomi.com/p/3000126/datasheet/-/11397811002 | 0.439
1007458 | 50 | 53 | 0.0000553035 | REHAU Compression sleeve RAUTITAN MX/LX 63 | 4007360031824 | 11397811002 | 1964 | https://oxomi.com/p/3000126/datasheet/-/11397811002 | 0.439
1007490 | 40 | 44 | 0.0000372872 | REHAU Compression sleeve RAUTITAN MX/LX 50 | 4007360031817 | 11397711002 | 1963 | https://oxomi.com/p/3000126/datasheet/-/11397711002 | 0.293
1007494 | 40 | 44 | 0.0000372872 | REHAU Compression sleeve RAUTITAN MX/LX 50 | 4007360031817 | 11397711002 | 1963 | https://oxomi.com/p/3000126/datasheet/-/11397711002 | 0.293
1007496 | 50 | 53 | 0.0000553035 | REHAU Compression sleeve RAUTITAN MX/LX 63 | 4007360031824 | 11397811002 | 1964 | https://oxomi.com/p/3000126/datasheet/-/11397811002 | 0.439
1007498 | 40 | 44 | 0.0000372872 | REHAU Compression sleeve RAUTITAN MX/LX 50 | 4007360031817 | 11397711002 | 1963 | https://oxomi.com/p/3000126/datasheet/-/11397711002 | 0.293
1007500 | 50 | 53 | 0.0000553035 | REHAU Compression sleeve RAUTITAN MX/LX 63 | 4007360031824 | 11397811002 | 1964 | https://oxomi.com/p/3000126/datasheet/-/11397811002 | 0.439
1007526 | 40 | 44 | 0.0000372872 | REHAU Compression sleeve RAUTITAN MX/LX 50 | 4007360031817 | 11397711002 | 1963 | https://oxomi.com/p/3000126/datasheet/-/11397711002 | 0.293
1007530 | 40 | 44 | 0.0000372872 | REHAU Compression sleeve RAUTITAN MX/LX 50 | 4007360031817 | 11397711002 | 1963 | https://oxomi.com/p/3000126/datasheet/-/11397711002 | 0.293
1007532 | 50 | 53 | 0.0000553035 | REHAU Compression sleeve RAUTITAN MX/LX 63 | 4007360031824 | 11397811002 | 1964 | https://oxomi.com/p/3000126/datasheet/-/11397811002 | 0.439
1007536 | 50 | 53 | 0.0000553035 | REHAU Compression sleeve RAUTITAN MX/LX 63 | 4007360031824 | 11397811002 | 1964 | https://oxomi.com/p/3000126/datasheet/-/11397811002 | 0.439
1007544 | 40 | 44 | 0.0000372872 | REHAU Compression sleeve RAUTITAN MX/LX 50 | 4007360031817 | 11397711002 | 1963 | https://oxomi.com/p/3000126/datasheet/-/11397711002 | 0.293
1007548 | 40 | 44 | 0.0000372872 | REHAU Compression sleeve RAUTITAN MX/LX 50 | 4007360031817 | 11397711002 | 1963 | https://oxomi.com/p/3000126/datasheet/-/11397711002 | 0.293
1007616 | 40 | 44 | 0.0000372872 | REHAU Compression sleeve RAUTITAN MX/LX 50 | 4007360031817 | 11397711002 | 1963 | https://oxomi.com/p/3000126/datasheet/-/11397711002 | 0.293
1067886 | 32 | 37 | 0.0000199643 | REHAU Compression sleeve RAUT. MX/LX 40 | 4007360186487 | 11372961001 | 1962 | https://oxomi.com/p/3000126/datasheet/-/11372961001 | 0.162
1067888 | 25 | 34 | 0.0000131097 | REHAU Compression sleeve RAUT. MX/LX 32 | 4007360168698 | 11371661001 | 1961 | https://oxomi.com/p/3000126/datasheet/-/11371661001 | 0.096
1067892 | 40 | 44 | 0.0000372872 | REHAU Compression sleeve RAUTITAN MX/LX 50 | 4007360031817 | 11397711002 | 1963 | https://oxomi.com/p/3000126/datasheet/-/11397711002 | 0.293
1067894 | 32 | 37 | 0.0000199643 | REHAU Compression sleeve RAUT. MX/LX 40 | 4007360186487 | 11372961001 | 1962 | https://oxomi.com/p/3000126/datasheet/-/11372961001 | 0.162
1067899 | 50 | 53 | 0.0000553035 | REHAU Compression sleeve RAUTITAN MX/LX 63 | 4007360031824 | 11397811002 | 1964 | https://oxomi.com/p/3000126/datasheet/-/11397811002 | 0.439
1067901 | 40 | 44 | 0.0000372872 | REHAU Compression sleeve RAUTITAN MX/LX 50 | 4007360031817 | 11397711002 | 1963 | https://oxomi.com/p/3000126/datasheet/-/11397711002 | 0.293
1067905 | 25 | 34 | 0.0000131097 | REHAU Compression sleeve RAUT. MX/LX 32 | 4007360168698 | 11371661001 | 1961 | https://oxomi.com/p/3000126/datasheet/-/11371661001 | 0.096
1067907 | 20 | 29 | 0.0000058041 | REHAU Compression sleeve RAUT. MX/LX +G 25 | 4007360377519 | 12596251402 | 1960 | https://oxomi.com/p/3000126/datasheet/-/12596251402 | 0.046
1067912 | 20 | 29 | 0.0000058041 | REHAU Compression sleeve RAUT. MX/LX +G 25 | 4007360377519 | 12596251402 | 1960 | https://oxomi.com/p/3000126/datasheet/-/12596251402 | 0.046
1067914 | 15 | 25 | 0.00000393937 | REHAU Compression sleeve RAUT. MX/LX 20 | 4007360031060 | 12596151002 | 1959 | https://oxomi.com/p/3000126/datasheet/-/12596151002 | 0.028
1067919 | 15 | 25 | 0.00000393937 | REHAU Compression sleeve RAUT. MX/LX 20 | 4007360031060 | 12596151002 | 1959 | https://oxomi.com/p/3000126/datasheet/-/12596151002 | 0.028
1077995 | 15 | 25 | 0.00000393937 | REHAU Compression sleeve RAUT. MX/LX 20 | 4007360031060 | 12596151002 | 1959 | https://oxomi.com/p/3000126/datasheet/-/12596151002 | 0.028
1077997 | 15 | 25 | 0.00000393937 | REHAU Compression sleeve RAUT. MX/LX 20 | 4007360031060 | 12596151002 | 1959 | https://oxomi.com/p/3000126/datasheet/-/12596151002 | 0.028
1078001 | 20 | 29 | 0.0000058041 | REHAU Compression sleeve RAUT. MX/LX +G 25 | 4007360377519 | 12596251402 | 1960 | https://oxomi.com/p/3000126/datasheet/-/12596251402 | 0.046
1078003 | 20 | 29 | 0.0000058041 | REHAU Compression sleeve RAUT. MX/LX +G 25 | 4007360377519 | 12596251402 | 1960 | https://oxomi.com/p/3000126/datasheet/-/12596251402 | 0.046
1078005 | 25 | 34 | 0.0000131097 | REHAU Compression sleeve RAUT. MX/LX 32 | 4007360168698 | 11371661001 | 1961 | https://oxomi.com/p/3000126/datasheet/-/11371661001 | 0.096
1078007 | 25 | 34 | 0.0000131097 | REHAU Compression sleeve RAUT. MX/LX 32 | 4007360168698 | 11371661001 | 1961 | https://oxomi.com/p/3000126/datasheet/-/11371661001 | 0.096
1078011 | 32 | 37 | 0.0000199643 | REHAU Compression sleeve RAUT. MX/LX 40 | 4007360186487 | 11372961001 | 1962 | https://oxomi.com/p/3000126/datasheet/-/11372961001 | 0.162
1078013 | 32 | 37 | 0.0000199643 | REHAU Compression sleeve RAUT. MX/LX 40 | 4007360186487 | 11372961001 | 1962 | https://oxomi.com/p/3000126/datasheet/-/11372961001 | 0.162
1078017 | 40 | 44 | 0.0000372872 | REHAU Compression sleeve RAUTITAN MX/LX 50 | 4007360031817 | 11397711002 | 1963 | https://oxomi.com/p/3000126/datasheet/-/11397711002 | 0.293
1078019 | 40 | 44 | 0.0000372872 | REHAU Compression sleeve RAUTITAN MX/LX 50 | 4007360031817 | 11397711002 | 1963 | https://oxomi.com/p/3000126/datasheet/-/11397711002 | 0.293
1078023 | 50 | 53 | 0.0000553035 | REHAU Compression sleeve RAUTITAN MX/LX 63 | 4007360031824 | 11397811002 | 1964 | https://oxomi.com/p/3000126/datasheet/-/11397811002 | 0.439
1078025 | 50 | 53 | 0.0000553035 | REHAU Compression sleeve RAUTITAN MX/LX 63 | 4007360031824 | 11397811002 | 1964 | https://oxomi.com/p/3000126/datasheet/-/11397811002 | 0.439
1078544 | 40 | 44 | 0.0000372872 | REHAU Compression sleeve RAUTITAN MX/LX 50 | 4007360031817 | 11397711002 | 1963 | https://oxomi.com/p/3000126/datasheet/-/11397711002 | 0.293
1078546 | 40 | 44 | 0.0000372872 | REHAU Compression sleeve RAUTITAN MX/LX 50 | 4007360031817 | 11397711002 | 1963 | https://oxomi.com/p/3000126/datasheet/-/11397711002 | 0.293
1078548 | 50 | 53 | 0.0000553035 | REHAU Compression sleeve RAUTITAN MX/LX 63 | 4007360031824 | 11397811002 | 1964 | https://oxomi.com/p/3000126/datasheet/-/11397811002 | 0.439
1078550 | 50 | 53 | 0.0000553035 | REHAU Compression sleeve RAUTITAN MX/LX 63 | 4007360031824 | 11397811002 | 1964 | https://oxomi.com/p/3000126/datasheet/-/11397811002 | 0.439
1078552 | 50 | 53 | 0.0000553035 | REHAU Compression sleeve RAUTITAN MX/LX 63 | 4007360031824 | 11397811002 | 1964 | https://oxomi.com/p/3000126/datasheet/-/11397811002 | 0.439
1078554 | 50 | 53 | 0.0000553035 | REHAU Compression sleeve RAUTITAN MX/LX 63 | 4007360031824 | 11397811002 | 1964 | https://oxomi.com/p/3000126/datasheet/-/11397811002 | 0.439
1078556 | 40 | 44 | 0.0000372872 | REHAU Compression sleeve RAUTITAN MX/LX 50 | 4007360031817 | 11397711002 | 1963 | https://oxomi.com/p/3000126/datasheet/-/11397711002 | 0.293
1078558 | 40 | 44 | 0.0000372872 | REHAU Compression sleeve RAUTITAN MX/LX 50 | 4007360031817 | 11397711002 | 1963 | https://oxomi.com/p/3000126/datasheet/-/11397711002 | 0.293
1078839 | 40 | 44 | 0.0000372872 | REHAU Compression sleeve RAUTITAN MX/LX 50 | 4007360031817 | 11397711002 | 1963 | https://oxomi.com/p/3000126/datasheet/-/11397711002 | 0.293
1078841 | 50 | 53 | 0.0000553035 | REHAU Compression sleeve RAUTITAN MX/LX 63 | 4007360031824 | 11397811002 | 1964 | https://oxomi.com/p/3000126/datasheet/-/11397811002 | 0.439
1078847 | 40 | 44 | 0.0000372872 | REHAU Compression sleeve RAUTITAN MX/LX 50 | 4007360031817 | 11397711002 | 1963 | https://oxomi.com/p/3000126/datasheet/-/11397711002 | 0.293
1078849 | 50 | 53 | 0.0000553035 | REHAU Compression sleeve RAUTITAN MX/LX 63 | 4007360031824 | 11397811002 | 1964 | https://oxomi.com/p/3000126/datasheet/-/11397811002 | 0.439
1078853 | 40 | 44 | 0.0000372872 | REHAU Compression sleeve RAUTITAN MX/LX 50 | 4007360031817 | 11397711002 | 1963 | https://oxomi.com/p/3000126/datasheet/-/11397711002 | 0.293
1078855 | 50 | 53 | 0.0000553035 | REHAU Compression sleeve RAUTITAN MX/LX 63 | 4007360031824 | 11397811002 | 1964 | https://oxomi.com/p/3000126/datasheet/-/11397811002 | 0.439
1078857 | 40 | 44 | 0.0000372872 | REHAU Compression sleeve RAUTITAN MX/LX 50 | 4007360031817 | 11397711002 | 1963 | https://oxomi.com/p/3000126/datasheet/-/11397711002 | 0.293
1078859 | 50 | 53 | 0.0000553035 | REHAU Compression sleeve RAUTITAN MX/LX 63 | 4007360031824 | 11397811002 | 1964 | https://oxomi.com/p/3000126/datasheet/-/11397811002 | 0.439
1078861 | 40 | 44 | 0.0000372872 | REHAU Compression sleeve RAUTITAN MX/LX 50 | 4007360031817 | 11397711002 | 1963 | https://oxomi.com/p/3000126/datasheet/-/11397711002 | 0.293
1078863 | 50 | 53 | 0.0000553035 | REHAU Compression sleeve RAUTITAN MX/LX 63 | 4007360031824 | 11397811002 | 1964 | https://oxomi.com/p/3000126/datasheet/-/11397811002 | 0.439
1078865 | 40 | 44 | 0.0000372872 | REHAU Compression sleeve RAUTITAN MX/LX 50 | 4007360031817 | 11397711002 | 1963 | https://oxomi.com/p/3000126/datasheet/-/11397711002 | 0.293
1078877 | 40 | 44 | 0.0000372872 | REHAU Compression sleeve RAUTITAN MX/LX 50 | 4007360031817 | 11397711002 | 1963 | https://oxomi.com/p/3000126/datasheet/-/11397711002 | 0.293
1078879 | 50 | 53 | 0.0000553035 | REHAU Compression sleeve RAUTITAN MX/LX 63 | 4007360031824 | 11397811002 | 1964 | https://oxomi.com/p/3000126/datasheet/-/11397811002 | 0.439
1078885 | 40 | 44 | 0.0000372872 | REHAU Compression sleeve RAUTITAN MX/LX 50 | 4007360031817 | 11397711002 | 1963 | https://oxomi.com/p/3000126/datasheet/-/11397711002 | 0.293
1078887 | 50 | 53 | 0.0000553035 | REHAU Compression sleeve RAUTITAN MX/LX 63 | 4007360031824 | 11397811002 | 1964 | https://oxomi.com/p/3000126/datasheet/-/11397811002 | 0.439
1078891 | 40 | 44 | 0.0000372872 | REHAU Compression sleeve RAUTITAN MX/LX 50 | 4007360031817 | 11397711002 | 1963 | https://oxomi.com/p/3000126/datasheet/-/11397711002 | 0.293
1078893 | 50 | 53 | 0.0000553035 | REHAU Compression sleeve RAUTITAN MX/LX 63 | 4007360031824 | 11397811002 | 1964 | https://oxomi.com/p/3000126/datasheet/-/11397811002 | 0.439
1078895 | 40 | 44 | 0.0000372872 | REHAU Compression sleeve RAUTITAN MX/LX 50 | 4007360031817 | 11397711002 | 1963 | https://oxomi.com/p/3000126/datasheet/-/11397711002 | 0.293
1078897 | 50 | 53 | 0.0000553035 | REHAU Compression sleeve RAUTITAN MX/LX 63 | 4007360031824 | 11397811002 | 1964 | https://oxomi.com/p/3000126/datasheet/-/11397811002 | 0.439
1078899 | 40 | 44 | 0.0000372872 | REHAU Compression sleeve RAUTITAN MX/LX 50 | 4007360031817 | 11397711002 | 1963 | https://oxomi.com/p/3000126/datasheet/-/11397711002 | 0.293
1078901 | 50 | 53 | 0.0000553035 | REHAU Compression sleeve RAUTITAN MX/LX 63 | 4007360031824 | 11397811002 | 1964 | https://oxomi.com/p/3000126/datasheet/-/11397811002 | 0.439
1078903 | 40 | 44 | 0.0000372872 | REHAU Compression sleeve RAUTITAN MX/LX 50 | 4007360031817 | 11397711002 | 1963 | https://oxomi.com/p/3000126/datasheet/-/11397711002 | 0.293
1078915 | 40 | 44 | 0.0000372872 | REHAU Compression sleeve RAUTITAN MX/LX 50 | 4007360031817 | 11397711002 | 1963 | https://oxomi.com/p/3000126/datasheet/-/11397711002 | 0.293
1078917 | 50 | 53 | 0.0000553035 | REHAU Compression sleeve RAUTITAN MX/LX 63 | 4007360031824 | 11397811002 | 1964 | https://oxomi.com/p/3000126/datasheet/-/11397811002 | 0.439
1078925 | 40 | 44 | 0.0000372872 | REHAU Compression sleeve RAUTITAN MX/LX 50 | 4007360031817 | 11397711002 | 1963 | https://oxomi.com/p/3000126/datasheet/-/11397711002 | 0.293
1078967 | 40 | 44 | 0.0000372872 | REHAU Compression sleeve RAUTITAN MX/LX 50 | 4007360031817 | 11397711002 | 1963 | https://oxomi.com/p/3000126/datasheet/-/11397711002 | 0.293
1078971 | 50 | 53 | 0.0000553035 | REHAU Compression sleeve RAUTITAN MX/LX 63 | 4007360031824 | 11397811002 | 1964 | https://oxomi.com/p/3000126/datasheet/-/11397811002 | 0.439
1078973 | 40 | 44 | 0.0000372872 | REHAU Compression sleeve RAUTITAN MX/LX 50 | 4007360031817 | 11397711002 | 1963 | https://oxomi.com/p/3000126/datasheet/-/11397711002 | 0.293
1079011 | 40 | 44 | 0.0000372872 | REHAU Compression sleeve RAUTITAN MX/LX 50 | 4007360031817 | 11397711002 | 1963 | https://oxomi.com/p/3000126/datasheet/-/11397711002 | 0.293
1079015 | 50 | 53 | 0.0000553035 | REHAU Compression sleeve RAUTITAN MX/LX 63 | 4007360031824 | 11397811002 | 1964 | https://oxomi.com/p/3000126/datasheet/-/11397811002 | 0.439
1079017 | 40 | 44 | 0.0000372872 | REHAU Compression sleeve RAUTITAN MX/LX 50 | 4007360031817 | 11397711002 | 1963 | https://oxomi.com/p/3000126/datasheet/-/11397711002 | 0.293
1079027 | 40 | 44 | 0.0000372872 | REHAU Compression sleeve RAUTITAN MX/LX 50 | 4007360031817 | 11397711002 | 1963 | https://oxomi.com/p/3000126/datasheet/-/11397711002 | 0.293
1079113 | 40 | 44 | 0.0000372872 | REHAU Compression sleeve RAUTITAN MX/LX 50 | 4007360031817 | 11397711002 | 1963 | https://oxomi.com/p/3000126/datasheet/-/11397711002 | 0.293
1079115 | 40 | 44 | 0.0000372872 | REHAU Compression sleeve RAUTITAN MX/LX 50 | 4007360031817 | 11397711002 | 1963 | https://oxomi.com/p/3000126/datasheet/-/11397711002 | 0.293
1079126 | 50 | 53 | 0.0000553035 | REHAU Compression sleeve RAUTITAN MX/LX 63 | 4007360031824 | 11397811002 | 1964 | https://oxomi.com/p/3000126/datasheet/-/11397811002 | 0.439
1079128 | 50 | 53 | 0.0000553035 | REHAU Compression sleeve RAUTITAN MX/LX 63 | 4007360031824 | 11397811002 | 1964 | https://oxomi.com/p/3000126/datasheet/-/11397811002 | 0.439
1086535 | 40 | 44 | 0.0000372872 | REHAU Compression sleeve RAUTITAN MX/LX 50 | 4007360031817 | 11397711002 | 1963 | https://oxomi.com/p/3000126/datasheet/-/11397711002 | 0.293
1086537 | 40 | 44 | 0.0000372872 | REHAU Compression sleeve RAUTITAN MX/LX 50 | 4007360031817 | 11397711002 | 1963 | https://oxomi.com/p/3000126/datasheet/-/11397711002 | 0.293
1086541 | 50 | 53 | 0.0000553035 | REHAU Compression sleeve RAUTITAN MX/LX 63 | 4007360031824 | 11397811002 | 1964 | https://oxomi.com/p/3000126/datasheet/-/11397811002 | 0.439
1086543 | 50 | 53 | 0.0000553035 | REHAU Compression sleeve RAUTITAN MX/LX 63 | 4007360031824 | 11397811002 | 1964 | https://oxomi.com/p/3000126/datasheet/-/11397811002 | 0.439

# IfcPipeFitting: Sleeve:LX 7,4 (48)
In: REHAU Starting view
Type - Material: Br, <Unnamed>
Type - Other - Category: Pipe Fittings; Family Name: Sleeve
Type - Constraints - Default Elevation: 0 mm
Type - Identity Data - Cost: 0; Description: LX 7,4; Manufacturer: REHAU; Model: LX 7,4; REHAU Info: 14.02.2024-420668-420668; Type Name: LX 7,4
Type - Materials and Finishes - Mat. Sleeve: Br
Type - Pset_ManufacturerTypeInformation - Manufacturer: REHAU
Pset_EnvironmentalImpactIndicators - Reference: Sleeve:LX 7,4; sets with these values: 2
Other - IsCustom: yes; Family: Sleeve; Family and Type: Sleeve: LX 7,4; T1: Sleeve DN; Type: LX 7,4; Type Id: 986514
Constraints - Elevation from Level: 0 mm; Level: REHAU Starting view; Moves With Nearby Elements: no
Data - PID Check: 0 mm; Language: Description en; Language Tender Text: Tender Text en; Region Check: Check DE; Region PID: PID DE; Region URL: Product URL DE
Dimensions - Area: 0.00262625 m2; Volume: 0.0000142985 m3
Identity Data - Sorting: 0; ETIM Class: EC011668; ETIM Group: EG015540; ETIM Name: Accessories/spare parts for fittings; PID: -; Tender text: -
Phasing - Phase Created: New Construction
Insulation - Insulation Thickness: 0 mm
Name (Sleeve:LX 7,4:...) | DN1 (mm) | L1 (mm) | Description long | GTIN | Product Group | Product URL | Weight
986597 | 10 | 15 | REHAU compression sleeve SDR 11/7,4 LX 12 x 1,1 / 12 x 1,7 / 12 x 2,0 | 4007360057114 | 1957 | https://oxomi.com/p/3000126/datasheet/-/11386131001 | 0.01
986599 | 10 | 15 | REHAU compression sleeve SDR 11/7,4 LX 12 x 1,1 / 12 x 1,7 / 12 x 2,0 | 4007360057114 | 1957 | https://oxomi.com/p/3000126/datasheet/-/11386131001 | 0.01
1005928 | 10 | 15 | REHAU compression sleeve SDR 11/7,4 LX 12 x 1,1 / 12 x 1,7 / 12 x 2,0 | 4007360057114 | 1957 | https://oxomi.com/p/3000126/datasheet/-/11386131001 | 0.01
1005930 | 10 | 15 | REHAU compression sleeve SDR 11/7,4 LX 12 x 1,1 / 12 x 1,7 / 12 x 2,0 | 4007360057114 | 1957 | https://oxomi.com/p/3000126/datasheet/-/11386131001 | 0.01
1005932 | 10 | 15 | REHAU compression sleeve SDR 11/7,4 LX 12 x 1,1 / 12 x 1,7 / 12 x 2,0 | 4007360057114 | 1957 | https://oxomi.com/p/3000126/datasheet/-/11386131001 | 0.01
1005936 | 12 | 24 | REHAU Compression sleeve RAUT. MX/LX 16 | 4007360031053 | 1958 | https://oxomi.com/p/3000126/datasheet/-/12596051002 | 0.025
1005938 | 12 | 24 | REHAU Compression sleeve RAUT. MX/LX 16 | 4007360031053 | 1958 | https://oxomi.com/p/3000126/datasheet/-/12596051002 | 0.025
1005940 | 12 | 24 | REHAU Compression sleeve RAUT. MX/LX 16 | 4007360031053 | 1958 | https://oxomi.com/p/3000126/datasheet/-/12596051002 | 0.025
1005991 | 12 | 24 | REHAU Compression sleeve RAUT. MX/LX 16 | 4007360031053 | 1958 | https://oxomi.com/p/3000126/datasheet/-/12596051002 | 0.025
1005993 | 10 | 15 | REHAU compression sleeve SDR 11/7,4 LX 12 x 1,1 / 12 x 1,7 / 12 x 2,0 | 4007360057114 | 1957 | https://oxomi.com/p/3000126/datasheet/-/11386131001 | 0.01
1005995 | 12 | 24 | REHAU Compression sleeve RAUT. MX/LX 16 | 4007360031053 | 1958 | https://oxomi.com/p/3000126/datasheet/-/12596051002 | 0.025
1006043 | 12 | 24 | REHAU Compression sleeve RAUT. MX/LX 16 | 4007360031053 | 1958 | https://oxomi.com/p/3000126/datasheet/-/12596051002 | 0.025
1006052 | 12 | 24 | REHAU Compression sleeve RAUT. MX/LX 16 | 4007360031053 | 1958 | https://oxomi.com/p/3000126/datasheet/-/12596051002 | 0.025
1006093 | 10 | 15 | REHAU compression sleeve SDR 11/7,4 LX 12 x 1,1 / 12 x 1,7 / 12 x 2,0 | 4007360057114 | 1957 | https://oxomi.com/p/3000126/datasheet/-/11386131001 | 0.01
1006109 | 12 | 24 | REHAU Compression sleeve RAUT. MX/LX 16 | 4007360031053 | 1958 | https://oxomi.com/p/3000126/datasheet/-/12596051002 | 0.025
1006113 | 12 | 24 | REHAU Compression sleeve RAUT. MX/LX 16 | 4007360031053 | 1958 | https://oxomi.com/p/3000126/datasheet/-/12596051002 | 0.025
1006127 | 12 | 24 | REHAU Compression sleeve RAUT. MX/LX 16 | 4007360031053 | 1958 | https://oxomi.com/p/3000126/datasheet/-/12596051002 | 0.025
1006129 | 10 | 15 | REHAU compression sleeve SDR 11/7,4 LX 12 x 1,1 / 12 x 1,7 / 12 x 2,0 | 4007360057114 | 1957 | https://oxomi.com/p/3000126/datasheet/-/11386131001 | 0.01
1006131 | 10 | 15 | REHAU compression sleeve SDR 11/7,4 LX 12 x 1,1 / 12 x 1,7 / 12 x 2,0 | 4007360057114 | 1957 | https://oxomi.com/p/3000126/datasheet/-/11386131001 | 0.01
1006161 | 12 | 24 | REHAU Compression sleeve RAUT. MX/LX 16 | 4007360031053 | 1958 | https://oxomi.com/p/3000126/datasheet/-/12596051002 | 0.025
1006163 | 12 | 24 | REHAU Compression sleeve RAUT. MX/LX 16 | 4007360031053 | 1958 | https://oxomi.com/p/3000126/datasheet/-/12596051002 | 0.025
1006168 | 12 | 24 | REHAU Compression sleeve RAUT. MX/LX 16 | 4007360031053 | 1958 | https://oxomi.com/p/3000126/datasheet/-/12596051002 | 0.025
1006170 | 12 | 24 | REHAU Compression sleeve RAUT. MX/LX 16 | 4007360031053 | 1958 | https://oxomi.com/p/3000126/datasheet/-/12596051002 | 0.025
1006172 | 10 | 15 | REHAU compression sleeve SDR 11/7,4 LX 12 x 1,1 / 12 x 1,7 / 12 x 2,0 | 4007360057114 | 1957 | https://oxomi.com/p/3000126/datasheet/-/11386131001 | 0.01
1006198 | 12 | 24 | REHAU Compression sleeve RAUT. MX/LX 16 | 4007360031053 | 1958 | https://oxomi.com/p/3000126/datasheet/-/12596051002 | 0.025
1006215 | 12 | 24 | REHAU Compression sleeve RAUT. MX/LX 16 | 4007360031053 | 1958 | https://oxomi.com/p/3000126/datasheet/-/12596051002 | 0.025
1007418 | 10 | 15 | REHAU compression sleeve SDR 11/7,4 LX 12 x 1,1 / 12 x 1,7 / 12 x 2,0 | 4007360057114 | 1957 | https://oxomi.com/p/3000126/datasheet/-/11386131001 | 0.01
1007420 | 10 | 15 | REHAU compression sleeve SDR 11/7,4 LX 12 x 1,1 / 12 x 1,7 / 12 x 2,0 | 4007360057114 | 1957 | https://oxomi.com/p/3000126/datasheet/-/11386131001 | 0.01
1007422 | 10 | 15 | REHAU compression sleeve SDR 11/7,4 LX 12 x 1,1 / 12 x 1,7 / 12 x 2,0 | 4007360057114 | 1957 | https://oxomi.com/p/3000126/datasheet/-/11386131001 | 0.01
1007468 | 10 | 15 | REHAU compression sleeve SDR 11/7,4 LX 12 x 1,1 / 12 x 1,7 / 12 x 2,0 | 4007360057114 | 1957 | https://oxomi.com/p/3000126/datasheet/-/11386131001 | 0.01
1007540 | 10 | 15 | REHAU compression sleeve SDR 11/7,4 LX 12 x 1,1 / 12 x 1,7 / 12 x 2,0 | 4007360057114 | 1957 | https://oxomi.com/p/3000126/datasheet/-/11386131001 | 0.01
1007564 | 10 | 15 | REHAU compression sleeve SDR 11/7,4 LX 12 x 1,1 / 12 x 1,7 / 12 x 2,0 | 4007360057114 | 1957 | https://oxomi.com/p/3000126/datasheet/-/11386131001 | 0.01
1007566 | 10 | 15 | REHAU compression sleeve SDR 11/7,4 LX 12 x 1,1 / 12 x 1,7 / 12 x 2,0 | 4007360057114 | 1957 | https://oxomi.com/p/3000126/datasheet/-/11386131001 | 0.01
1007596 | 10 | 15 | REHAU compression sleeve SDR 11/7,4 LX 12 x 1,1 / 12 x 1,7 / 12 x 2,0 | 4007360057114 | 1957 | https://oxomi.com/p/3000126/datasheet/-/11386131001 | 0.01
1067921 | 12 | 24 | REHAU Compression sleeve RAUT. MX/LX 16 | 4007360031053 | 1958 | https://oxomi.com/p/3000126/datasheet/-/12596051002 | 0.025
1077983 | 10 | 15 | REHAU compression sleeve SDR 11/7,4 LX 12 x 1,1 / 12 x 1,7 / 12 x 2,0 | 4007360057114 | 1957 | https://oxomi.com/p/3000126/datasheet/-/11386131001 | 0.01
1077985 | 10 | 15 | REHAU compression sleeve SDR 11/7,4 LX 12 x 1,1 / 12 x 1,7 / 12 x 2,0 | 4007360057114 | 1957 | https://oxomi.com/p/3000126/datasheet/-/11386131001 | 0.01
1077989 | 12 | 24 | REHAU Compression sleeve RAUT. MX/LX 16 | 4007360031053 | 1958 | https://oxomi.com/p/3000126/datasheet/-/12596051002 | 0.025
1077991 | 12 | 24 | REHAU Compression sleeve RAUT. MX/LX 16 | 4007360031053 | 1958 | https://oxomi.com/p/3000126/datasheet/-/12596051002 | 0.025
1440896 | 12 | 24 | REHAU Compression sleeve RAUT. MX/LX 16 | 4007360031053 | 1958 | https://oxomi.com/p/3000126/datasheet/-/12596051002 | 0.025
1440898 | 12 | 24 | REHAU Compression sleeve RAUT. MX/LX 16 | 4007360031053 | 1958 | https://oxomi.com/p/3000126/datasheet/-/12596051002 | 0.025
1440942 | 10 | 15 | REHAU compression sleeve SDR 11/7,4 LX 12 x 1,1 / 12 x 1,7 / 12 x 2,0 | 4007360057114 | 1957 | https://oxomi.com/p/3000126/datasheet/-/11386131001 | 0.01
