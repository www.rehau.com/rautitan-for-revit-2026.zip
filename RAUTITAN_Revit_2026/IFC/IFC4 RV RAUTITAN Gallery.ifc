Properties of the parts of a building model (IFC4), part 3 of 10

# IfcPipeFitting: RAUTITAN_Adapter_external_thread:RTI A external DE (14)
Name (RAUTITAN_Adapter_external_thread:RTI A external DE:...) | A (deg) | DN1 (mm) | DN2 (mm) | ID1 (mm) | ID2 (mm) | Maximum Size (mm) | Minimum Size (mm) | Size = Overall Size | SWL (mm) | SWL/2 (mm) | Volume (m3) | Z1 (mm) | Z2 (mm) | Description long | GTIN | PID | Weight
1441702 | 45 | 12 | 15 | 9.9 | 15 | 15 | 12 | 15 mmø-12 mmø | 21 | 10.5 | 0.00000682737 | 8.97 | 7.72 | REHAU Übergang RAUTITAN RX+ 16 - R 1/2 | 4061264397257 | 14563111001 | 0.049
1442918 | 45 | 12 | 20 | 9.9 | 19 | 20 | 12 | 20 mmø-12 mmø | 27 | 13.5 | 0.00000953155 | 8.97 | 6.5 | REHAU Übergang RAUTITAN RX+ 16 - R 3/4 | 4061264397264 | 14563121001 | 0.072
1442920 | 60 | 15 | 15 | 12.5 | 15 | 15 | 15 | 15 mmø-15 mmø | 18 | 9 | 0.00000872263 | 3.33 | 13.11 | REHAU Übergang RAUTITAN RX+ 20 - R 1/2 | 4061264397288 | 14563141001 | 0.06
1442922 | 60 | 15 | 20 | 12.5 | 19 | 20 | 15 | 20 mmø-15 mmø | 18 | 9 | 0.0000100112 | 3.35 | 13.11 | REHAU Übergang RAUTITAN RX+ 20 - R 3/4 | 4061264397295 | 14563151001 | 0.074
1442924 | 60 | 20 | 15 | 15.2 | 15 | 20 | 15 | 20 mmø-15 mmø | 22 | 11 | 0.00001245 | 3.54 | 11.17 | REHAU Übergang RAUTITAN RX+ 25 - R 1/2 | 4061264397318 | 14563171001 | 0.088
1442926 | 60 | 20 | 20 | 15.2 | 19 | 20 | 20 | 20 mmø-20 mmø | 22 | 11 | 0.0000147651 | 3.54 | 13.68 | REHAU Übergang RAUTITAN RX+ 25 - R 3/4 | 4061264397325 | 14563181001 | 0.102
1442928 | 45 | 20 | 25 | 15.2 | 25.5 | 25 | 20 | 25 mmø-20 mmø | 34 | 17 | 0.0000178754 | 9.72 | 6.7 | REHAU Übergang RAUTITAN RX+ 25 - R 1 | 4061264397332 | 14563191001 | 0.132
1442930 | 60 | 25 | 20 | 20 | 19 | 25 | 20 | 25 mmø-20 mmø | 27 | 13.5 | 0.0000218589 | 4.33 | 12.65 | REHAU Übergang RAUTITAN RX+ 32 - R 3/4 | 4061264397349 | 14563201001 | 0.146
1442932 | 60 | 25 | 25 | 20 | 25.5 | 25 | 25 | 25 mmø-25 mmø | 27 | 13.5 | 0.0000240241 | 4.33 | 14.19 | REHAU Übergang RAUTITAN RX+ 32 - R 1 | 4061264397356 | 14563211001 | 0.16
1442934 | 60 | 32 | 32 | 23.5 | 32 | 32 | 32 | 32 mmø-32 mmø | 32 | 16 | 0.0000461137 | 5.5 | 18.17 | REHAU Übergang RAUTITAN RX+ 40 - R 1 1/4 | 4061264397370 | 14563231001 | 0.325
1442936 | 60 | 40 | 40 | 30.5 | 37.5 | 40 | 40 | 40 mmø-40 mmø | 40 | 20 | 0.0000679767 | 5.25 | 18.29 | REHAU Übergang RAUTITAN RX+ 50 - R 1 1/2 | 4061264397394 | 14563251001 | 0.464
1442938 | 60 | 50 | 50 | 39.5 | 49.5 | 50 | 50 | 50 mmø-50 mmø | 49 | 24.5 | 0.000110526 | 5.77 | 19.68 | REHAU Übergang RAUTITAN RX+ 63 - R 2 | 4061264397400 | 14563261001 | 0.76
1443131 | 45 | 12 | 25 | 9.9 | 25.5 | 25 | 12 | 25 mmø-12 mmø | 34 | 17 | 0.000014868 | 8.97 | 7.87 | REHAU Übergang RAUTITAN RX+ 16 - R 1 | 4061264397271 | 14563131001 | 0.105
1443285 | 45 | 15 | 25 | 12.5 | 25.5 | 25 | 15 | 25 mmø-15 mmø | 34 | 17 | 0.0000150441 | 9.44 | 6.76 | REHAU Übergang RAUTITAN RX+ 20 - R 1 | 4061264397301 | 14563161001 | 0.115

# IfcPipeFitting: RAUTITAN_Ball valve block elbow:RAUTITAN_Ball valve block elbow, RAUTITAN_Ball valve block elbow:RAUTITAN_Ball valve block elbow:1087023
In: REHAU Starting view
Type - Material: Brass silver
Type - Other - Category: Pipe Fittings; Family Name: RAUTITAN_Ball valve block elbow; T1: RTI_Ball valve block elbow
Type - Constraints - Default Elevation: 0 mm
Type - Data - Language: Description EN; Region Check: Check DE; Region PID: PID DE
Type - Identity Data - Manufacturer: REHAU; Model: RAUTITAN; Type Name: RAUTITAN_Ball valve block elbow
Type - Pset_ManufacturerTypeInformation - Manufacturer: REHAU
Pset_EnvironmentalImpactIndicators - Reference: RAUTITAN_Ball valve block elbow:RAUTITAN_Ball valve block elbow; sets with these values: 2
Other - IsCustom: no; Family: RAUTITAN_Ball valve block elbow; Family and Type: RAUTITAN_Ball valve block elbow: RAUTITAN_Ball valve block elbow; Type: RAUTITAN_Ball valve block elbow; Type Id: 1089489
Constraints - Elevation from Level: 0 mm; Level: REHAU Starting view; Moves With Nearby Elements: no
Data - PID Check: 1 mm
Dimensions - Area: 0.0175132 m2; Volume: 0.0000583847 m3
Identity Data - Description long: REHAU Ball valve block male G 1/2 x G 3/4, elbow; GTIN: 4007360190996; PID: 12407371001; Weight: 472
Phasing - Phase Created: New Construction
Insulation - Insulation Thickness: 0 mm

# IfcPipeFitting: RAUTITAN_Ball valve block transition:RAUTITAN_Ball valve block transition, RAUTITAN_Ball valve block transition:RAUTITAN_Ball valve block transition:1087025
In: REHAU Starting view
Type - Material: Brass silver
Type - Other - Category: Pipe Fittings; Family Name: RAUTITAN_Ball valve block transition; T1: RTI_Ball valve block transition
Type - Constraints - Default Elevation: 0 mm
Type - Data - Language: Description EN; Region Check: Check DE; Region PID: PID DE
Type - Identity Data - Manufacturer: REHAU; Model: RAUTITAN; Type Name: RAUTITAN_Ball valve block transition
Type - Pset_ManufacturerTypeInformation - Manufacturer: REHAU
Pset_EnvironmentalImpactIndicators - Reference: RAUTITAN_Ball valve block transition:RAUTITAN_Ball valve block transition; sets with these values: 2
Other - IsCustom: no; Family: RAUTITAN_Ball valve block transition; Family and Type: RAUTITAN_Ball valve block transition: RAUTITAN_Ball valve block transition; Type: RAUTITAN_Ball valve block transition; Type Id: 1089491
Constraints - Elevation from Level: 0 mm; Level: REHAU Starting view; Moves With Nearby Elements: no
Data - PID Check: 1 mm
Dimensions - Area: 0.0125872 m2; Volume: 0.0000394414 m3
Identity Data - Description long: REHAU Ball valve block male G 1/2 x G 3/4, transition; GTIN: 4007360190989; PID: 12407271001; Weight: 348
Phasing - Phase Created: New Construction
Insulation - Insulation Thickness: 0 mm

# IfcPipeFitting: RAUTITAN_Corner_LX:RTI LX C DN (8)
In: REHAU Starting view
Type - Material: Br
Type - Other - Category: Pipe Fittings; Family Name: RAUTITAN_Corner_LX; Max sleeve: 32 mm; Min sleeve: 12 mm; Sleeve LX: Sleeve : LX 7,4; Sleeve PX: Sleeve : LX 7,4; T1: RTI Corner LX; T2: RTI Corner LX P1
Type - Constraints - Default Elevation: 0 mm
Type - Data - Language: Description en; Language Tender Text: Tender Text en; Region Check: Check DE; Region PID: PID DE; Region URL: Product URL DE; T3: Sleeve DN
Type - Identity Data - Assembly Code: D2090800; Classification Number: 23.60.30.11.14; Manufacturer: REHAU; Model: RAUTITAN; REHAU Info: 14.02.2024-420668-420668; Type Name: RTI LX C DN
Type - Materials and Finishes - Mat. Error: Error; Mat. Fitting: Br
Type - Mechanical - K Coefficient: 3.6; K Coefficient Table: Regular 45, 90 and 180 Elbow; Loss Method: K Coefficient
Type - Pset_ManufacturerTypeInformation - Manufacturer: REHAU
Classification: D2090800 (Uniformat)
Pset_EnvironmentalImpactIndicators - Reference: RAUTITAN_Corner_LX:RTI LX C DN; sets with these values: 2
Other - Family: RAUTITAN_Corner_LX; Family and Type: RAUTITAN_Corner_LX: RTI LX C DN; Sleeve DN1: Sleeve : LX 7,4; Sleeve DN2: Sleeve : LX 7,4; Type: RTI LX C DN; Type Id: 767005; IsCustom: no
Constraints - Elevation from Level: 0 mm; Level: REHAU Starting view
Data - PID Check: 1 mm
Dimensions - Area: 0.00465431 m2
Graphics - Use Annotation Scale: no
Identity Data - Sorting: 0; ETIM Class: EC003024; ETIM Group: EG015540; ETIM Name: Fitting with 2 connections; Tender text: -
Mechanical - System Classification: Undefined
Phasing - Phase Created: New Construction
Insulation - Insulation Thickness: 0 mm
Name (RAUTITAN_Corner_LX:RTI LX C DN:...) | L1 (mm) | L2 (mm) | Angle (deg) | Di1 (mm) | DN1 (mm) = DN2 (mm) = Maximum Size (mm) = Minimum Size (mm) | Size = Overall Size | Volume (m3) | Description long | GTIN | PID | Product Group | Product URL | Weight
885472 | 19.7 | 23.5 | 90 | 12.5 | 15 | 15 mmø-15 mmø | 0.0000144354 | REHAU Elbow RAUTITAN LX +G 20 - 20, 90 degree | 4007360543174 | 13129861001 | 1686 | https://oxomi.com/p/3000126/datasheet/-/13129861001 | 0.1
885485 | 23.4 | 27.6 | 90 | 15.2 | 20 | 20 mmø-20 mmø | 0.000027148 | REHAU Elbow RAUTITAN LX +G 25 - 25, 90 degree | 4007360543181 | 13129871001 | 1689 | https://oxomi.com/p/3000126/datasheet/-/13129871001 | 0.16
885598 | 26.5 | 31.5 | 90 | 20 | 25 | 25 mmø-25 mmø | 0.0000378291 | REHAU Elbow RAUTITAN LX +G 32 - 32, 90 degree | 4007360543198 | 13129881001 | 1690 | https://oxomi.com/p/3000126/datasheet/-/13129881001 | 0.31
885683 | 33 | 40 | 90 | 23 | 32 | 32 mmø-32 mmø | 0.0000748314 | REHAU Elbow RAUTITAN LX +G 40 - 40, 90 degree | 4007360543204 | 13129891001 | 1691 | https://oxomi.com/p/3000126/datasheet/-/13129891001 | 0.59
885698 | 39 | 46 | 90 | 30 | 40 | 40 mmø-40 mmø | 0.000112783 | REHAU Elbow RAUTITAN LX 50 - 50, 90 degree | 4007360458768 | 11681531001 | 1675 | https://oxomi.com/p/3000126/datasheet/-/11681531001 | 0.96
885872 | 45.5 | 54 | 90 | 39 | 50 | 50 mmø-50 mmø | 0.000183732 | REHAU Elbow RAUTITAN LX 63 - 63, 90 degree | 4007360458720 | 11681551001 | 1676 | https://oxomi.com/p/3000126/datasheet/-/11681551001 | 1.4
885987 | 20.8 | 29.3 | 45 | 39 | 50 | 50 mmø-50 mmø | 0.000151105 | REHAU Elbow RAUTITAN LX 63 - 63, 45 degree | 4007360458713 | 11681541001 | 1668 | https://oxomi.com/p/3000126/datasheet/-/11681541001 | 1.27
886085 | 19 | 26 | 45 | 30 | 40 | 40 mmø-40 mmø | 0.0000917925 | REHAU Elbow RAUTITAN LX 50 - 50, 45 degree | 4007360458751 | 11681521001 | 1667 | https://oxomi.com/p/3000126/datasheet/-/11681521001 | 0.72

# IfcPipeFitting: RAUTITAN_Corner_LX:RTI LX C DN (2)
In: REHAU Starting view
Type - Material: Error, Br
Type - Other - Category: Pipe Fittings; Family Name: RAUTITAN_Corner_LX; Max sleeve: 32 mm; Min sleeve: 12 mm; Sleeve LX: Sleeve : LX 7,4; Sleeve PX: Sleeve : LX 7,4; T1: RTI Corner LX; T2: RTI Corner LX P1
Type - Constraints - Default Elevation: 0 mm
Type - Data - Language: Description en; Language Tender Text: Tender Text en; Region Check: Check DE; Region PID: PID DE; Region URL: Product URL DE; T3: Sleeve DN
Type - Identity Data - Assembly Code: D2090800; Classification Number: 23.60.30.11.14; Manufacturer: REHAU; Model: RAUTITAN; REHAU Info: 14.02.2024-420668-420668; Type Name: RTI LX C DN
Type - Materials and Finishes - Mat. Error: Error; Mat. Fitting: Br
Type - Mechanical - K Coefficient: 3.6; K Coefficient Table: Regular 45, 90 and 180 Elbow; Loss Method: K Coefficient
Type - Pset_ManufacturerTypeInformation - Manufacturer: REHAU
Classification: D2090800 (Uniformat)
Pset_EnvironmentalImpactIndicators - Reference: RAUTITAN_Corner_LX:RTI LX C DN; sets with these values: 2
Other - Family: RAUTITAN_Corner_LX; Family and Type: RAUTITAN_Corner_LX: RTI LX C DN; IsCustom: yes; Sleeve DN1: Sleeve : LX 7,4; Sleeve DN2: Sleeve : LX 7,4; Type: RTI LX C DN; Type Id: 767005
Constraints - Elevation from Level: 0 mm; Level: REHAU Starting view
Data - PID Check: 0 mm
Dimensions - Angle: 90 deg; Area: 0.00465431 m2; Volume: 0.0000321717 m3
Graphics - Use Annotation Scale: no
Identity Data - ETIM Class: EC003024; ETIM Group: EG015540; ETIM Name: Fitting with 2 connections; PID: -; Sorting: 0; Tender text: -
Mechanical - System Classification: Undefined
Phasing - Phase Created: New Construction
Insulation - Insulation Thickness: 0 mm
Name (RAUTITAN_Corner_LX:RTI LX C DN:...) | L1 (mm) | L2 (mm) | Di1 (mm) | DN1 (mm) = DN2 (mm) = Maximum Size (mm) = Minimum Size (mm) | Size = Overall Size | Description long | GTIN | Product Group | Product URL | Weight
884892 | 15 | 18 | 6.6 | 10 | 10 mmø-10 mmø | REHAU Elbow RAUTITAN LX 12 - 12, 90 degree | 4007360468903 | 1670 | https://oxomi.com/p/3000126/datasheet/-/11681421001 | 0.039
1440894 | 17.7 | 21 | 9.9 | 12 | 12 mmø-12 mmø | REHAU Elbow RAUTITAN LX +G 16 - 16, 90 degree | 4007360543167 | 1685 | https://oxomi.com/p/3000126/datasheet/-/13129851001 | 0.065

# IfcPipeFitting: RAUTITAN_Corner_LX:RTI LX/PX C DN (8)
In: REHAU Starting view
Type - Material: Br
Type - Other - Category: Pipe Fittings; Sleeve LX: Sleeve : LX 7,4; Family Name: RAUTITAN_Corner_LX; Max sleeve: 32 mm; Min sleeve: 12 mm; Sleeve PX: Sleeve : PX 7,4; T1: RTI Corner LX; T2: RTI Corner LX P1
Type - Constraints - Default Elevation: 0 mm
Type - Data - Language: Description en; Language Tender Text: Tender Text en; Region Check: Check DE; Region PID: PID DE; Region URL: Product URL DE; T3: Sleeve DN
Type - Identity Data - Assembly Code: D2090800; Classification Number: 23.60.30.11.14; Manufacturer: REHAU; Model: RAUTITAN; REHAU Info: 14.02.2024-420668-420668; Type Name: RTI LX/PX C DN
Type - Materials and Finishes - Mat. Error: Error; Mat. Fitting: Br
Type - Mechanical - K Coefficient: 3.6; Loss Method: K Coefficient; K Coefficient Table: Regular 45, 90 and 180 Elbow
Type - Pset_ManufacturerTypeInformation - Manufacturer: REHAU
Classification: D2090800 (Uniformat)
Pset_EnvironmentalImpactIndicators - Reference: RAUTITAN_Corner_LX:RTI LX/PX C DN; sets with these values: 2
Other - Family: RAUTITAN_Corner_LX; IsCustom: no; Family and Type: RAUTITAN_Corner_LX: RTI LX/PX C DN; Type: RTI LX/PX C DN; Type Id: 767007
Constraints - Elevation from Level: 0 mm; Level: REHAU Starting view
Data - PID Check: 1 mm
Dimensions - Area: 0.00465431 m2
Graphics - Use Annotation Scale: no
Identity Data - Sorting: 0; ETIM Class: EC003024; ETIM Group: EG015540; ETIM Name: Fitting with 2 connections; Tender text: -
Mechanical - System Classification: Undefined
Phasing - Phase Created: New Construction
Insulation - Insulation Thickness: 0 mm
Name (RAUTITAN_Corner_LX:RTI LX/PX C DN:...) | Sleeve DN1 = Sleeve DN2 | L1 (mm) | L2 (mm) | Angle (deg) | Di1 (mm) | DN1 (mm) = DN2 (mm) = Maximum Size (mm) = Minimum Size (mm) | Size = Overall Size | Volume (m3) | Description long | GTIN | PID | Product Group | Product URL | Weight
961602 | Sleeve : PX 7,4 | 19.7 | 23.5 | 90 | 12.5 | 15 | 15 mmø-15 mmø | 0.0000144354 | REHAU Elbow RAUTITAN LX +G 20 - 20, 90 degree | 4007360543174 | 13129861001 | 1686 | https://oxomi.com/p/3000126/datasheet/-/13129861001 | 0.1
961608 | Sleeve : PX 7,4 | 23.4 | 27.6 | 90 | 15.2 | 20 | 20 mmø-20 mmø | 0.000027148 | REHAU Elbow RAUTITAN LX +G 25 - 25, 90 degree | 4007360543181 | 13129871001 | 1689 | https://oxomi.com/p/3000126/datasheet/-/13129871001 | 0.16
961614 | Sleeve : PX 7,4 | 26.5 | 31.5 | 90 | 20 | 25 | 25 mmø-25 mmø | 0.0000378291 | REHAU Elbow RAUTITAN LX +G 32 - 32, 90 degree | 4007360543198 | 13129881001 | 1690 | https://oxomi.com/p/3000126/datasheet/-/13129881001 | 0.31
961620 | Sleeve : PX 7,4 | 33 | 40 | 90 | 23 | 32 | 32 mmø-32 mmø | 0.0000748314 | REHAU Elbow RAUTITAN LX +G 40 - 40, 90 degree | 4007360543204 | 13129891001 | 1691 | https://oxomi.com/p/3000126/datasheet/-/13129891001 | 0.59
986855 | Sleeve : LX 7,4 | 39 | 46 | 90 | 30 | 40 | 40 mmø-40 mmø | 0.000112783 | REHAU Elbow RAUTITAN LX 50 - 50, 90 degree | 4007360458768 | 11681531001 | 1675 | https://oxomi.com/p/3000126/datasheet/-/11681531001 | 0.96
986868 | Sleeve : LX 7,4 | 45.5 | 54 | 90 | 39 | 50 | 50 mmø-50 mmø | 0.000183732 | REHAU Elbow RAUTITAN LX 63 - 63, 90 degree | 4007360458720 | 11681551001 | 1676 | https://oxomi.com/p/3000126/datasheet/-/11681551001 | 1.4
986992 | Sleeve : LX 7,4 | 20.8 | 29.3 | 45 | 39 | 50 | 50 mmø-50 mmø | 0.000151105 | REHAU Elbow RAUTITAN LX 63 - 63, 45 degree | 4007360458713 | 11681541001 | 1668 | https://oxomi.com/p/3000126/datasheet/-/11681541001 | 1.27
986994 | Sleeve : LX 7,4 | 19 | 26 | 45 | 30 | 40 | 40 mmø-40 mmø | 0.0000917925 | REHAU Elbow RAUTITAN LX 50 - 50, 45 degree | 4007360458751 | 11681521001 | 1667 | https://oxomi.com/p/3000126/datasheet/-/11681521001 | 0.72

# IfcPipeFitting: RAUTITAN_Corner_LX:RTI LX/PX C DN (2)
In: REHAU Starting view
Type - Material: Error, Br
Type - Other - Category: Pipe Fittings; Sleeve LX: Sleeve : LX 7,4; Family Name: RAUTITAN_Corner_LX; Max sleeve: 32 mm; Min sleeve: 12 mm; Sleeve PX: Sleeve : PX 7,4; T1: RTI Corner LX; T2: RTI Corner LX P1
Type - Constraints - Default Elevation: 0 mm
Type - Data - Language: Description en; Language Tender Text: Tender Text en; Region Check: Check DE; Region PID: PID DE; Region URL: Product URL DE; T3: Sleeve DN
Type - Identity Data - Assembly Code: D2090800; Classification Number: 23.60.30.11.14; Manufacturer: REHAU; Model: RAUTITAN; REHAU Info: 14.02.2024-420668-420668; Type Name: RTI LX/PX C DN
Type - Materials and Finishes - Mat. Error: Error; Mat. Fitting: Br
Type - Mechanical - K Coefficient: 3.6; Loss Method: K Coefficient; K Coefficient Table: Regular 45, 90 and 180 Elbow
Type - Pset_ManufacturerTypeInformation - Manufacturer: REHAU
Classification: D2090800 (Uniformat)
Pset_EnvironmentalImpactIndicators - Reference: RAUTITAN_Corner_LX:RTI LX/PX C DN; sets with these values: 2
Other - Family: RAUTITAN_Corner_LX; IsCustom: yes; Family and Type: RAUTITAN_Corner_LX: RTI LX/PX C DN; Type: RTI LX/PX C DN; Type Id: 767007
Constraints - Elevation from Level: 0 mm; Level: REHAU Starting view
Data - PID Check: 0 mm
Dimensions - Angle: 90 deg; Area: 0.00465431 m2; Volume: 0.0000321717 m3
Graphics - Use Annotation Scale: no
Identity Data - Sorting: 0; ETIM Class: EC003024; ETIM Group: EG015540; ETIM Name: Fitting with 2 connections; PID: -; Tender text: -
Mechanical - System Classification: Undefined
Phasing - Phase Created: New Construction
Insulation - Insulation Thickness: 0 mm
Name (RAUTITAN_Corner_LX:RTI LX/PX C DN:...) | Sleeve DN1 = Sleeve DN2 | L1 (mm) | L2 (mm) | Di1 (mm) | DN1 (mm) = DN2 (mm) = Maximum Size (mm) = Minimum Size (mm) | Size = Overall Size | Description long | GTIN | Product Group | Product URL | Weight
961596 | Sleeve : PX 7,4 | 17.7 | 21 | 9.9 | 12 | 12 mmø-12 mmø | REHAU Elbow RAUTITAN LX +G 16 - 16, 90 degree | 4007360543167 | 1685 | https://oxomi.com/p/3000126/datasheet/-/13129851001 | 0.065
1441230 | Sleeve : LX 7,4 | 15 | 18 | 6.6 | 10 | 10 mmø-10 mmø | REHAU Elbow RAUTITAN LX 12 - 12, 90 degree | 4007360468903 | 1670 | https://oxomi.com/p/3000126/datasheet/-/11681421001 | 0.039

# IfcPipeFitting: RAUTITAN_Corner_PX:RTI PX C DN (9)
In: REHAU Starting view
Type - Material: PX
Type - Other - Category: Pipe Fittings; Family Name: RAUTITAN_Corner_PX; T1: RTI Corner PX; T2: RTI Corner PX P1
Type - Constraints - Default Elevation: 0 mm
Type - Data - Language: Description en; Language Tender Text: Tender Text en; Region Check: Check DE; Region PID: PID DE; Region URL: Product URL DE; T3: Sleeve DN
Type - Identity Data - Assembly Code: D2090800; Classification Number: 23.60.30.11.14; Manufacturer: REHAU; Model: RAUTITAN; REHAU Info: 14.02.2024-420668-420668; Type Name: RTI PX C DN
Type - Materials and Finishes - Mat. Fitting: PX
Type - Mechanical - K Coefficient: 3.6; Loss Method: K Coefficient; K Coefficient Table: Regular 45, 90 and 180 Elbow
Type - Pset_ManufacturerTypeInformation - Manufacturer: REHAU
Classification: D2090800 (Uniformat)
Pset_EnvironmentalImpactIndicators - Reference: RAUTITAN_Corner_PX:RTI PX C DN; sets with these values: 2
Other - IsCustom: no; Family: RAUTITAN_Corner_PX; Family and Type: RAUTITAN_Corner_PX: RTI PX C DN; Type: RTI PX C DN; Type Id: 769804
Constraints - Elevation from Level: 0 mm; Level: REHAU Starting view
Data - PID Check: 1 mm
Dimensions - Area: 0.00465431 m2
Graphics - Use Annotation Scale: no
Identity Data - Sorting: 0; ETIM Class: EC003024; ETIM Group: EG015540; ETIM Name: Fitting with 2 connections; Tender text: -
Mechanical - System Classification: Undefined
Phasing - Phase Created: New Construction
Insulation - Insulation Thickness: 0 mm
Name (RAUTITAN_Corner_PX:RTI PX C DN:...) | L1 (mm) | LS1 (mm) | Angle (deg) | Di1 (mm) | DN1 (mm) = Maximum Size (mm) = Minimum Size (mm) | Size = Overall Size | Volume (m3) | Description long | GTIN | PID | Product Group | Product URL | Weight
1078268 | 21 | 23.7 | 90 | 9 | 12 | 12 mmø-12 mmø | 0.00000909026 | REHAU Elbow RAUTITAN PX 16 - 16, 90 degree | 4007360366452 | 11600211001 | 1653 | https://oxomi.com/p/3000126/datasheet/-/11600211001 | 0.0117
1078270 | 22.5 | 25 | 90 | 11.2 | 15 | 15 mmø-15 mmø | 0.0000158241 | REHAU Elbow RAUTITAN PX 20 - 20, 90 degree | 4007360366469 | 11600221001 | 1654 | https://oxomi.com/p/3000126/datasheet/-/11600221001 | 0.0184
1078272 | 25 | 27.2 | 90 | 13.5 | 20 | 20 mmø-20 mmø | 0.00002449 | REHAU Elbow RAUTITAN PX 25 - 25, 90 degree | 4007360366476 | 11600231001 | 1655 | https://oxomi.com/p/3000126/datasheet/-/11600231001 | 0.0313
1078274 | 27.5 | 34 | 90 | 18.1 | 25 | 25 mmø-25 mmø | 0.0000431598 | REHAU Elbow RAUTITAN PX 32 - 32, 90 degree | 4007360366483 | 11600241001 | 1656 | https://oxomi.com/p/3000126/datasheet/-/11600241001 | 0.0555
1078276 | 31 | 37.8 | 90 | 22 | 32 | 32 mmø-32 mmø | 0.0000838716 | REHAU Elbow RAUTITAN PX 40 - 40, 90 degree | 4007360366490 | 11600251001 | 1657 | https://oxomi.com/p/3000126/datasheet/-/11600251001 | 0.1046
1078288 | 13.7132 | 25 | 45 | 11.2 | 15 | 15 mmø-15 mmø | 0.0000130836 | REHAU Elbow RAUTITAN PX 20 - 20, 45 degree | 4007360376918 | 11600521001 | 1642 | https://oxomi.com/p/3000126/datasheet/-/11600521001 | 0.0169
1078290 | 16.2132 | 27.2 | 45 | 13.5 | 20 | 20 mmø-20 mmø | 0.0000212051 | REHAU Elbow RAUTITAN PX 25 - 25, 45 degree | 4007360376925 | 11600531001 | 1643 | https://oxomi.com/p/3000126/datasheet/-/11600531001 | 0.0281
1078292 | 18.7132 | 34 | 45 | 18.1 | 25 | 25 mmø-25 mmø | 0.0000382794 | REHAU Elbow RAUTITAN PX 32 - 32, 45 degree | 4007360376932 | 11600541001 | 1644 | https://oxomi.com/p/3000126/datasheet/-/11600541001 | 0.0515
1078294 | 22.2132 | 37.8 | 45 | 22 | 32 | 32 mmø-32 mmø | 0.0000745967 | REHAU Elbow RAUTITAN PX 40 - 40, 45 degree | 4007360376949 | 11600551001 | 1645 | https://oxomi.com/p/3000126/datasheet/-/11600551001 | 0.0931

# IfcPipeFitting: RAUTITAN_Corner_RX+ stabil:RTI RX+ stabil C DN (4)
In: REHAU Starting view
Type - Material: RX
Type - Other - Category: Pipe Fittings; Family Name: RAUTITAN_Corner_RX+ stabil; T1: RTI Corner RX+ stabil; T2: RTI Corner RX+ stabil P1
Type - Constraints - Default Elevation: 0 mm
Type - Data - Language: Description en; Language Tender Text: Tender Text en; Region Check: Check DE; Region PID: PID DE; Region URL: Product URL DE; T3: Sleeve DN
Type - Identity Data - Assembly Code: D2090800; Classification Number: 23.60.30.11.14; Manufacturer: REHAU; Model: RAUTITAN; REHAU Info: 14.02.2024-420668-420668; Type Name: RTI RX+ stabil C DN
Type - Materials and Finishes - Mat. Fitting: RX
Type - Mechanical - Loss Method: K Coefficient; K Coefficient: 0.6; K Coefficient Table: Regular 45, 90 and 180 Elbow
Type - Pset_ManufacturerTypeInformation - Manufacturer: REHAU
Classification: D2090800 (Uniformat)
Pset_EnvironmentalImpactIndicators - Reference: RAUTITAN_Corner_RX+ stabil:RTI RX+ stabil C DN; sets with these values: 2
Other - IsCustom: no; Family: RAUTITAN_Corner_RX+ stabil; Family and Type: RAUTITAN_Corner_RX+ stabil: RTI RX+ stabil C DN; Type: RTI RX+ stabil C DN; Type Id: 772619
Constraints - Elevation from Level: 0 mm; Level: REHAU Starting view
Data - PID Check: 1 mm
Dimensions - Area: 0.00465431 m2
Graphics - Use Annotation Scale: no
Identity Data - Sorting: 0; ETIM Class: EC003024; ETIM Group: EG015540; ETIM Name: Fitting with 2 connections; Tender text: -
Mechanical - System Classification: Undefined
Phasing - Phase Created: New Construction
Insulation - Insulation Thickness: 0 mm
Name (RAUTITAN_Corner_RX+ stabil:RTI RX+ stabil C DN:...) | L1 (mm) | LS1 (mm) | R (mm) | Z1 (mm) | Z2 (mm) | Angle (deg) | Di1 (mm) | DN1 (mm) = Maximum Size (mm) = Minimum Size (mm) | Do1 (mm) | Size = Overall Size | Volume (m3) | Description long | GTIN | PID | Product Group | Product URL | Weight
1078278 | 39.5 | 45 | 11.8 | 32.55 | 32.55 | 90 | 33.5 | 40 | 41.5 | 40 mmø-40 mmø | 0.000102383 | REHAU Bend RAUTITAN RX+ stabil 50 - 50, 90 degree | 4062178676070 | 14600331001 | 1693 | https://oxomi.com/p/3000126/datasheet/-/14600331001 | 0.879
1078280 | 47.1 | 53 | 13.8 | 41.15 | 41.15 | 90 | 45.5 | 50 | 54.7 | 50 mmø-50 mmø | 0.000176815 | REHAU Bend RAUTITAN RX+ stabil 63 - 63, 90 degree | 4062178676087 | 14600341001 | 1694 | https://oxomi.com/p/3000126/datasheet/-/14600341001 | 1.475
1078284 | 21.5 | 53 | 10 | 15.4709 | 37.35 | 45 | 45.5 | 50 | 54.7 | 50 mmø-50 mmø | 0.00015137 | REHAU Bend RAUTITAN RX+ stabil 63 - 63, 45 degree | 4062178676063 | 14600321001 | 1697 | https://oxomi.com/p/3000126/datasheet/-/14600321001 | 1.256
1078286 | 19.5 | 45 | 11 | 13.1513 | 31.75 | 45 | 33.5 | 40 | 41.5 | 40 mmø-40 mmø | 0.000089473 | REHAU Bend RAUTITAN RX+ stabil 50 - 50, 45 degree | 4062178676056 | 14600311001 | 1696 | https://oxomi.com/p/3000126/datasheet/-/14600311001 | 0.762

# IfcPipeFitting: RAUTITAN_Corner_RX+:RTI RX+ C DN (8)
In: REHAU Starting view
Type - Material: RX
Type - Other - Category: Pipe Fittings; Family Name: RAUTITAN_Corner_RX+; Max Sleeve: 32 mm; Sleeve LX: Sleeve : LX 7,4; Sleeve PX: Sleeve : PX 7,4; T1: RTI Corner RX; T2: RTI Corner RX P1
Type - Constraints - Default Elevation: 0 mm
Type - Data - Language: Description en; Language Tender Text: Tender Text en; Region Check: Check DE; Region PID: PID DE; Region URL: Product URL DE; T3: Sleeve DN
Type - Identity Data - Assembly Code: D2090800; Classification Number: 23.60.30.11.14; Manufacturer: REHAU; Model: RAUTITAN; REHAU Info: 14.02.2024-420668-420668; Type Name: RTI RX+ C DN
Type - Materials and Finishes - Mat. Fitting: RX
Type - Mechanical - Loss Method: K Coefficient; K Coefficient: 0.6; K Coefficient Table: Regular 45, 90 and 180 Elbow
Type - Pset_ManufacturerTypeInformation - Manufacturer: REHAU
Classification: D2090800 (Uniformat)
Pset_EnvironmentalImpactIndicators - Reference: RAUTITAN_Corner_RX+:RTI RX+ C DN; sets with these values: 2
Other - IsCustom: no; Family: RAUTITAN_Corner_RX+; Family and Type: RAUTITAN_Corner_RX+: RTI RX+ C DN; Type: RTI RX+ C DN; Type Id: 775437
Constraints - Elevation from Level: 0 mm; Level: REHAU Starting view
Data - PID Check: 1 mm
Dimensions - Area: 0.00465431 m2
Graphics - Use Annotation Scale: no
Identity Data - Sorting: 0; ETIM Class: EC003024; ETIM Group: EG015540; ETIM Name: Fitting with 2 connections; Tender text: -
Mechanical - System Classification: Undefined
Phasing - Phase Created: New Construction
Insulation - Insulation Thickness: 0 mm
Name (RAUTITAN_Corner_RX+:RTI RX+ C DN:...) | Sleeve DN1 = Sleeve DN2 | L1 (mm) | LS1 (mm) | R (mm) | Z1 (mm) | Z2 (mm) | Angle (deg) | Di1 (mm) | DN1 (mm) = Maximum Size (mm) = Minimum Size (mm) | Do1 (mm) | Size = Overall Size | Volume (m3) | Description long | GTIN | PID | Product Group | Product URL | Weight
1078409 | Sleeve : PX 7,4 | 17.6 | 23.7 | 3.1 | 11.65 | 11.65 | 90 | 9.9 | 12 | 17.1 | 12 mmø-12 mmø | 0.00000884644 | REHAU Bend RAUTITAN RX+ 16 - 16, 90 degree | 4061264398438 | 14564291001 | 1678 | https://oxomi.com/p/3000126/datasheet/-/14564291001 | 0.067
1078411 | Sleeve : PX 7,4 | 19.6 | 25 | 6.1 | 16.15 | 16.15 | 90 | 12.5 | 15 | 20.1 | 15 mmø-15 mmø | 0.0000130478 | REHAU Bend RAUTITAN RX+ 20 - 20, 90 degree | 4061264398445 | 14564301001 | 1679 | https://oxomi.com/p/3000126/datasheet/-/14564301001 | 0.095
1078413 | Sleeve : PX 7,4 | 23.3 | 27.2 | 6.4 | 18.9 | 18.9 | 90 | 15.2 | 20 | 25 | 20 mmø-20 mmø | 0.0000245764 | REHAU Bend RAUTITAN RX+ 25 - 25, 90 degree | 4061264398452 | 14564311001 | 1680 | https://oxomi.com/p/3000126/datasheet/-/14564311001 | 0.163
1078415 | Sleeve : PX 7,4 | 26.4 | 34 | 9.4 | 23.4 | 23.4 | 90 | 20 | 25 | 28 | 25 mmø-25 mmø | 0.0000352509 | REHAU Bend RAUTITAN RX+ 32 - 32, 90 degree | 4061264398469 | 14564321001 | 1681 | https://oxomi.com/p/3000126/datasheet/-/14564321001 | 0.268
1078417 | Sleeve : LX 7,4 | 39.2 | 45 | 12 | 32.5 | 32.5 | 90 | 30.5 | 40 | 41 | 40 mmø-40 mmø | 0.000108634 | REHAU Bend RAUTITAN RX+ 50 - 50, 90 degree | 4061264397219 | 14563071001 | 1682 | https://oxomi.com/p/3000126/datasheet/-/14563071001 | 0.854
1078419 | Sleeve : LX 7,4 | 47.7 | 53 | 16 | 41 | 41 | 90 | 39.5 | 50 | 50 | 50 mmø-50 mmø | 0.00017904 | REHAU Bend RAUTITAN RX+ 63 - 63, 90 degree | 4061264397226 | 14563081001 | 1683 | https://oxomi.com/p/3000126/datasheet/-/14563081001 | 1.365
1078423 | Sleeve : LX 7,4 | 21.5 | 53 | 8 | 13.669 | 33 | 45 | 39.5 | 50 | 50 | 50 mmø-50 mmø | 0.00015202 | REHAU Bend RAUTITAN RX+ 63 - 63, 45 degree | 4061264397240 | 14563101001 | 1651 | https://oxomi.com/p/3000126/datasheet/-/14563101001 | 1.193
1078425 | Sleeve : LX 7,4 | 19.4 | 45 | 6 | 10.9767 | 26.5 | 45 | 30.5 | 40 | 41 | 40 mmø-40 mmø | 0.0000926646 | REHAU Bend RAUTITAN RX+ 50 - 50, 45 degree | 4061264397233 | 14563091001 | 1650 | https://oxomi.com/p/3000126/datasheet/-/14563091001 | 0.725

# IfcPipeFitting: RAUTITAN_LX_C.Coupling:RTI LX/PX C.C DN (4)
In: REHAU Starting view
Type - Material: Br, Error
Type - Other - Category: Pipe Fittings; Family Name: RAUTITAN_LX_C.Coupling; T1: RTI C.Coupling; T2: Sleeve DN
Type - Constraints - Default Elevation: 0 mm
Type - Data - Language: Description en; Language Tender Text: Tender Text nl; Region Check: Check DE; Region PID: PID DE; Region URL: Product URL NL
Type - Identity Data - Assembly Code: D2090800; Classification Number: 23.60.30.11.14; Manufacturer: REHAU; Model: RAUTITAN; REHAU Info: 14.02.2024-420668-420668; Type Name: RTI LX/PX C.C DN
Type - Materials and Finishes - Mat. LX: Br
Type - Mechanical - Loss Method: K Coefficient; K Coefficient: 0.6; K Coefficient Table: Reducer/Coupling/Union/Increaser
Type - Pset_ManufacturerTypeInformation - Manufacturer: REHAU
Classification: D2090800 (Uniformat)
Pset_EnvironmentalImpactIndicators - Reference: RAUTITAN_LX_C.Coupling:RTI LX/PX C.C DN; sets with these values: 2
Other - IsCustom: yes; Family: RAUTITAN_LX_C.Coupling; Family and Type: RAUTITAN_LX_C.Coupling: RTI LX/PX C.C DN; Type: RTI LX/PX C.C DN; Type Id: 999821
Constraints - Elevation from Level: 0 mm; Level: REHAU Starting view
Data - PID Check: 0 mm
Graphics - Use Annotation Scale: no
Identity Data - Sorting: 0; ETIM Class: EC003024; ETIM Group: EG015540; ETIM Name: Fitting with 2 connections; PID: -; Tender text: -
Mechanical - System Classification: Undefined
Phasing - Phase Created: New Construction
Insulation - Insulation Thickness: 0 mm
Name (RAUTITAN_LX_C.Coupling:RTI LX/PX C.C DN:...) | L.8 (mm) | L.9 (mm) | Segmentation (deg) | Area (m2) | Di1 (mm) | DN1 (mm) = Minimum Size (mm) | DN2 (mm) = Maximum Size (mm) | Size = Overall Size | Volume (m3) | Description long | GTIN | Product Group | Product URL | Weight
1078154 | 5 | 14.3 | 60 | 0.00877517 | 9.9 | 12 | 15 | 15 mmø-12 mmø | 0.0000440591 | Crim.adaptor 16-Cu15 RAUT.LX+G | 4007360542757 | 1559 | https://oxomi.com/p/3001042/datasheet/-/13140991001 | 0.08
1078158 | 5 | 14.3 | 60 | 0.00923904 | 12.5 | 15 | 15 | 15 mmø-15 mmø | 0.0000455856 | Crim.adaptor 20-Cu15 RAUT.LX+G | 4007360542764 | 1560 | https://oxomi.com/p/3001042/datasheet/-/13141091001 | 0.086
1078561 | 6.5 | 16.3 | 45 | 0.0105787 | 12.5 | 15 | 22 | 22 mmø-15 mmø | 0.000050644 | Crim.adaptor 20-Cu15 RAUT.LX+G | 4007360542764 | 1560 | https://oxomi.com/p/3001042/datasheet/-/13141091001 | 0.086
1078565 | 6.5 | 16.3 | 45 | 0.0114373 | 15.2 | 20 | 22 | 22 mmø-20 mmø | 0.0000538481 | REHAU Crim. adaptor RAUTITAN LX +G 25 - Cu 22 | 4007360543501 | 1562 | https://oxomi.com/p/3001042/datasheet/-/13130781001 | 0.165

# IfcPipeFitting: RAUTITAN_Radiator TAG16:RAUTITAN_Radiator TAG16, RAUTITAN_Radiator TAG16:RAUTITAN_Radiator TAG16:1087027
In: REHAU Starting view
Type - Material: Stainless steel
Type - Other - Category: Pipe Fittings; Family Name: RAUTITAN_Radiator TAG16; T1: RTI_Radiator TAG16
Type - Constraints - Default Elevation: 0 mm
Type - Data - Language: Description EN; Region Check: Check DE; Region PID: PID DE
Type - Identity Data - Manufacturer: REHAU; Model: RAUTITAN; Type Name: RAUTITAN_Radiator TAG16
Type - Pset_ManufacturerTypeInformation - Manufacturer: REHAU
Pset_EnvironmentalImpactIndicators - Reference: RAUTITAN_Radiator TAG16:RAUTITAN_Radiator TAG16; sets with these values: 2
Other - IsCustom: no; Family: RAUTITAN_Radiator TAG16; Family and Type: RAUTITAN_Radiator TAG16: RAUTITAN_Radiator TAG16; Height product: 250 mm; Type: RAUTITAN_Radiator TAG16; Type Id: 1089423
Constraints - Elevation from Level: 0 mm; Level: REHAU Starting view; Moves With Nearby Elements: no
Data - PID Check: 1 mm
Dimensions - Area: 0.0141243 m2; Height: 200 mm; Volume: 0.0000218427 m3
Identity Data - Description long: REHAU Radiator connecting tee RAUTITAN 16 / 250 mm; GTIN: 4007360068042; PID: 12662821001; Weight: 187
Phasing - Phase Created: New Construction
Insulation - Insulation Thickness: 0 mm

# IfcPipeFitting: RAUTITAN_Radiator TAG20:RAUTITAN_Radiator TAG20, RAUTITAN_Radiator TAG20:RAUTITAN_Radiator TAG20:1087029
In: REHAU Starting view
Type - Material: Stainless steel
Type - Other - Category: Pipe Fittings; Family Name: RAUTITAN_Radiator TAG20; T1: RTI_Radiator TAG20
Type - Constraints - Default Elevation: 0 mm
Type - Data - Language: Description EN; Region Check: Check DE; Region PID: PID DE
Type - Identity Data - Type Name: RAUTITAN_Radiator TAG20
Pset_EnvironmentalImpactIndicators - Reference: RAUTITAN_Radiator TAG20:RAUTITAN_Radiator TAG20; sets with these values: 2
Other - IsCustom: no; Family: RAUTITAN_Radiator TAG20; Family and Type: RAUTITAN_Radiator TAG20: RAUTITAN_Radiator TAG20; Height product: 250 mm; Type: RAUTITAN_Radiator TAG20; Type Id: 1089425
Constraints - Elevation from Level: 0 mm; Level: REHAU Starting view; Moves With Nearby Elements: no
Data - PID Check: 1 mm
Dimensions - Area: 0.0152334 m2; Height: 200 mm; Volume: 0.0000261819 m3
Identity Data - Description long: REHAU Radiator connecting tee RAUTITAN 20 / 250 mm; GTIN: 4007360068066; PID: 12663021001; Weight: 222
Phasing - Phase Created: New Construction
Insulation - Insulation Thickness: 0 mm

# IfcPipeFitting: RAUTITAN_Radiator WAG16 Brass:RAUTITAN_Radiator WAG16 Brass, RAUTITAN_Radiator WAG16 Brass:RAUTITAN_Radiator WAG16 Brass:1087031
In: REHAU Starting view
Type - Material: Brass
Type - Other - Category: Pipe Fittings; Family Name: RAUTITAN_Radiator WAG16 Brass; T1: RTI_Radiator WAG16 Brass
Type - Constraints - Default Elevation: 0 mm
Type - Data - Language: Description EN; Region Check: Check DE; Region PID: PID DE
Type - Identity Data - Type Name: RAUTITAN_Radiator WAG16 Brass
Pset_EnvironmentalImpactIndicators - Reference: RAUTITAN_Radiator WAG16 Brass:RAUTITAN_Radiator WAG16 Brass; sets with these values: 2
Other - IsCustom: no; Family: RAUTITAN_Radiator WAG16 Brass; Family and Type: RAUTITAN_Radiator WAG16 Brass: RAUTITAN_Radiator WAG16 Brass; Height product: 250 mm; Type: RAUTITAN_Radiator WAG16 Brass; Type Id: 1089427
Constraints - Elevation from Level: 0 mm; Level: REHAU Starting view; Moves With Nearby Elements: no
Data - PID Check: 1 mm
Dimensions - Area: 0.0132459 m2; Height: 200 mm; Volume: 0.0000162473 m3
Identity Data - Description long: REHAU Cu/Brass Connecting bend set RAUT. nat. 16/250 mm incl. floor fixg. bracket; GTIN: 4007360160104; PID: 12664121001; Weight: 432
Phasing - Phase Created: New Construction
Insulation - Insulation Thickness: 0 mm

# IfcPipeFitting: RAUTITAN_Radiator WAG16:RAUTITAN_Radiator WAG16, RAUTITAN_Radiator WAG16:RAUTITAN_Radiator WAG16:1087033
In: REHAU Starting view
Type - Material: Stainless steel
Type - Other - Category: Pipe Fittings; Family Name: RAUTITAN_Radiator WAG16; T1: RTI_Radiator WAG16
Type - Constraints - Default Elevation: 0 mm
Type - Data - Language: Description EN; Region Check: Check DE; Region PID: PID DE
Type - Identity Data - Manufacturer: REHAU; Model: RAUTITAN; Type Name: RAUTITAN_Radiator WAG16
Type - Pset_ManufacturerTypeInformation - Manufacturer: REHAU
Pset_EnvironmentalImpactIndicators - Reference: RAUTITAN_Radiator WAG16:RAUTITAN_Radiator WAG16; sets with these values: 2
Other - IsCustom: no; Family: RAUTITAN_Radiator WAG16; Family and Type: RAUTITAN_Radiator WAG16: RAUTITAN_Radiator WAG16; Height product: 250 mm; Type: RAUTITAN_Radiator WAG16; Type Id: 1089429
Constraints - Elevation from Level: 0 mm; Level: REHAU Starting view; Moves With Nearby Elements: no
Data - PID Check: 1 mm
Dimensions - Area: 0.0120097 m2; Height: 200 mm; Volume: 0.0000125611 m3
Identity Data - Description long: REHAU Radiator connecting bend RAUTITAN 16 / 250 mm; GTIN: 4007360068004; PID: 12662421001; Weight: 128
Phasing - Phase Created: New Construction
Insulation - Insulation Thickness: 0 mm

# IfcPipeFitting: RAUTITAN_Radiator WAG20:RAUTITAN_Radiator WAG20, RAUTITAN_Radiator WAG20:RAUTITAN_Radiator WAG20:1087035
In: REHAU Starting view
Type - Material: Stainless steel
Type - Other - Category: Pipe Fittings; Family Name: RAUTITAN_Radiator WAG20; T1: RTI_Radiator WAG20
Type - Constraints - Default Elevation: 0 mm
Type - Data - Language: Description EN; Region Check: Check DE; Region PID: PID DE
Type - Identity Data - Manufacturer: REHAU; Model: RAUTITAN; Type Name: RAUTITAN_Radiator WAG20
Type - Pset_ManufacturerTypeInformation - Manufacturer: REHAU
Pset_EnvironmentalImpactIndicators - Reference: RAUTITAN_Radiator WAG20:RAUTITAN_Radiator WAG20; sets with these values: 2
Other - IsCustom: no; Family: RAUTITAN_Radiator WAG20; Family and Type: RAUTITAN_Radiator WAG20: RAUTITAN_Radiator WAG20; Height product: 250 mm; Type: RAUTITAN_Radiator WAG20; Type Id: 1089431
Constraints - Elevation from Level: 0 mm; Level: REHAU Starting view; Moves With Nearby Elements: no
Data - PID Check: 1 mm
Dimensions - Area: 0.0132068 m2; Height: 200 mm; Volume: 0.0000164999 m3
Identity Data - Description long: REHAU Radiator connecting bend RAUTITAN 20 / 250 mm; GTIN: 4007360068028; PID: 12662621001; Weight: 156
Phasing - Phase Created: New Construction
Insulation - Insulation Thickness: 0 mm

# IfcPipeFitting: RAUTITAN_Radiatorconnection box:RAUTITAN_Radiatorconnection box, RAUTITAN_Radiatorconnection box:RAUTITAN_Radiatorconnection box:1087037
In: REHAU Starting view
Type - Material: RAUTITAN PX, PU Hard Foam
Type - Other - Category: Pipe Fittings; Family Name: RAUTITAN_Radiatorconnection box; T1: RTI_Radiatorconnection box
Type - Constraints - Default Elevation: 0 mm
Type - Data - Language: Description EN; Region Check: Check DE; Region PID: PID DE
Type - Dimensions - Depth installation: 270 mm; Height installation: 540 mm
Type - Identity Data - Manufacturer: REHAU; Model: RAUTITAN; Type Name: RAUTITAN_Radiatorconnection box
Type - Pset_ManufacturerTypeInformation - Manufacturer: REHAU
Pset_EnvironmentalImpactIndicators - Reference: RAUTITAN_Radiatorconnection box:RAUTITAN_Radiatorconnection box; sets with these values: 2
Other - IsCustom: no; Family: RAUTITAN_Radiatorconnection box; Family and Type: RAUTITAN_Radiatorconnection box: RAUTITAN_Radiatorconnection box; Type: RAUTITAN_Radiatorconnection box; Type Id: 1089433
Constraints - Level: REHAU Starting view; Moves With Nearby Elements: no; Elevation from Level: -500 mm
Data - PID Check: 1 mm
Dimensions - Area: 0.085542 m2; Volume: 0.000858846 m3
Identity Data - Description long: REHAU Radiator connection block RAUTITAN stabil; GTIN: 4007360557287; PID: 11101981001; Weight: 220
Phasing - Phase Created: New Construction
Insulation - Insulation Thickness: 0 mm

# IfcPipeFitting: RAUTITAN_Sleeve PX2:RTI S PX 2 (14)
In: REHAU Starting view
Type - Material: RAUTITAN PX
Type - Other - Category: Pipe Fittings; Family Name: RAUTITAN_Sleeve PX2; T1: RTI Sleeve PX; T2: RTI Sleeve PX D
Type - Constraints - Default Elevation: 0 mm
Type - Identity Data - REHAU Info: 2024.06.11-420668-420668; Type Name: RTI S PX 2
Pset_EnvironmentalImpactIndicators - Reference: RAUTITAN_Sleeve PX2:RTI S PX 2; sets with these values: 2
Other - IsCustom: no; Family: RAUTITAN_Sleeve PX2; Family and Type: RAUTITAN_Sleeve PX2: RTI S PX 2; Type: RTI S PX 2; Type Id: 1089417
Constraints - Elevation from Level: 0 mm; Level: REHAU Starting view; Moves With Nearby Elements: no
Data - Language: Description EN; PID Check: 1 mm; Region Check: Check DE; Region PID: PID DE
Phasing - Phase Created: New Construction
Insulation - Insulation Thickness: 0 mm
Name (RAUTITAN_Sleeve PX2:RTI S PX 2:...) | Area (m2) | DN (mm) | L1 (mm) | Volume (m3) | Description long | GTIN | PID | Weight
1441766 | 0.0015541 | 12 | 23.7 | 0.00000312848 | REHAU Compression sleeve RAUTITAN PX 16 | 4007360361204 | 11600011001 | 7.6
1442980 | 0.0015541 | 12 | 23.7 | 0.00000312848 | REHAU Compression sleeve RAUTITAN PX 16 | 4007360361204 | 11600011001 | 7.6
1442982 | 0.00205237 | 15 | 25 | 0.00000516767 | REHAU Compression sleeve RAUTITAN PX 20 | 4007360361211 | 11600021001 | 11
1442984 | 0.00205237 | 15 | 25 | 0.00000516767 | REHAU Compression sleeve RAUTITAN PX 20 | 4007360361211 | 11600021001 | 11
1442986 | 0.00280656 | 20 | 27.2 | 0.0000087028 | REHAU Compression sleeve RAUTITAN PX 25 | 4007360361228 | 11600031001 | 15.828
1442988 | 0.00280656 | 20 | 27.2 | 0.0000087028 | REHAU Compression sleeve RAUTITAN PX 25 | 4007360361228 | 11600031001 | 15.828
1442990 | 0.00280656 | 20 | 27.2 | 0.0000087028 | REHAU Compression sleeve RAUTITAN PX 25 | 4007360361228 | 11600031001 | 15.828
1442992 | 0.00447557 | 25 | 34 | 0.0000174355 | REHAU Compression sleeve RAUTITAN PX 32 | 4007360361235 | 11600041001 | 27.828
1442994 | 0.00447557 | 25 | 34 | 0.0000174355 | REHAU Compression sleeve RAUTITAN PX 32 | 4007360361235 | 11600041001 | 27.828
1442996 | 0.00631173 | 32 | 37.8 | 0.0000303041 | REHAU Compression sleeve RAUTITAN PX 40 | 4007360361242 | 11600051001 | 38.61
1442998 | 0.00864619 | 40 | 45 | 0.0000353695 | REHAU Compr. sleeve RAUTITAN PX stabil 50 | 4062178755416 | 11602061001 | 67.3
1443000 | 0.0130302 | 50 | 53 | 0.0000702282 | REHAU Compr. sleeve RAUTITAN PX stabil 63 | 4062178755423 | 11602071001 | 110.6
1443133 | 0.0015541 | 12 | 23.7 | 0.00000312848 | REHAU Compression sleeve RAUTITAN PX 16 | 4007360361204 | 11600011001 | 7.6
1443287 | 0.00205237 | 15 | 25 | 0.00000516767 | REHAU Compression sleeve RAUTITAN PX 20 | 4007360361211 | 11600021001 | 11

# IfcPipeFitting: RAUTITAN_Sleeve PX:DN1 (16)
In: REHAU Starting view
Type - Material: RAUTITAN PX
Type - Other - Category: Pipe Fittings; Family Name: RAUTITAN_Sleeve PX; T1: RTI Sleeve PX; T2: RTI Sleeve PX D
Type - Constraints - Default Elevation: 0 mm
Type - Identity Data - REHAU Info: 2024.06.11-420668-420668; Type Name: DN1
Pset_EnvironmentalImpactIndicators - Reference: RAUTITAN_Sleeve PX:DN1; sets with these values: 2
Other - IsCustom: no; Family: RAUTITAN_Sleeve PX; Family and Type: RAUTITAN_Sleeve PX: DN1; Type: DN1; Type Id: 1344532
Constraints - Level: REHAU Starting view; Moves With Nearby Elements: no; Elevation from Level: -43.3 mm
Data - Language: Description EN; PID Check: 1 mm; Region Check: Check DE; Region PID: PID DE
Phasing - Phase Created: New Construction
Insulation - Insulation Thickness: 0 mm
Name (RAUTITAN_Sleeve PX:DN1:...) | DN (mm) | L1 (mm) | Volume (m3) | Description long | GTIN | PID | Weight
1087041 | 12 | 23.7 | 0.00000312848 | REHAU Compression sleeve RAUTITAN PX 16 | 4007360361204 | 11600011001 | 7.6
1087043 | 12 | 23.7 | 0.00000312848 | REHAU Compression sleeve RAUTITAN PX 16 | 4007360361204 | 11600011001 | 7.6
1087047 | 12 | 23.7 | 0.00000312848 | REHAU Compression sleeve RAUTITAN PX 16 | 4007360361204 | 11600011001 | 7.6
1087049 | 12 | 23.7 | 0.00000312848 | REHAU Compression sleeve RAUTITAN PX 16 | 4007360361204 | 11600011001 | 7.6
1087053 | 15 | 25 | 0.00000516767 | REHAU Compression sleeve RAUTITAN PX 20 | 4007360361211 | 11600021001 | 11
1087055 | 15 | 25 | 0.00000516767 | REHAU Compression sleeve RAUTITAN PX 20 | 4007360361211 | 11600021001 | 11
1087059 | 15 | 25 | 0.00000516767 | REHAU Compression sleeve RAUTITAN PX 20 | 4007360361211 | 11600021001 | 11
1087061 | 15 | 25 | 0.00000516767 | REHAU Compression sleeve RAUTITAN PX 20 | 4007360361211 | 11600021001 | 11
1087065 | 20 | 27.2 | 0.0000087028 | REHAU Compression sleeve RAUTITAN PX 25 | 4007360361228 | 11600031001 | 15.828
1087067 | 20 | 27.2 | 0.0000087028 | REHAU Compression sleeve RAUTITAN PX 25 | 4007360361228 | 11600031001 | 15.828
1087071 | 20 | 27.2 | 0.0000087028 | REHAU Compression sleeve RAUTITAN PX 25 | 4007360361228 | 11600031001 | 15.828
1087073 | 20 | 27.2 | 0.0000087028 | REHAU Compression sleeve RAUTITAN PX 25 | 4007360361228 | 11600031001 | 15.828
1087077 | 12 | 23.7 | 0.00000312848 | REHAU Compression sleeve RAUTITAN PX 16 | 4007360361204 | 11600011001 | 7.6
1087079 | 15 | 25 | 0.00000516767 | REHAU Compression sleeve RAUTITAN PX 20 | 4007360361211 | 11600021001 | 11
1087083 | 15 | 25 | 0.00000516767 | REHAU Compression sleeve RAUTITAN PX 20 | 4007360361211 | 11600021001 | 11
1087085 | 12 | 23.7 | 0.00000312848 | REHAU Compression sleeve RAUTITAN PX 16 | 4007360361204 | 11600011001 | 7.6

# IfcPipeFitting: RAUTITAN_Sleeve PX:RTI S PX (68)
In: REHAU Starting view
Type - Material: RAUTITAN PX
Type - Other - Category: Pipe Fittings; Family Name: RAUTITAN_Sleeve PX; T1: RTI Sleeve PX; T2: RTI Sleeve PX D
Type - Constraints - Default Elevation: 0 mm
Type - Identity Data - REHAU Info: 2024.06.11-420668-420668; Type Name: RTI S PX
Pset_EnvironmentalImpactIndicators - Reference: RAUTITAN_Sleeve PX:RTI S PX; sets with these values: 2
Other - IsCustom: no; Family: RAUTITAN_Sleeve PX; Family and Type: RAUTITAN_Sleeve PX: RTI S PX; Type: RTI S PX; Type Id: 1191209
Constraints - Level: REHAU Starting view; Moves With Nearby Elements: no
Data - PID Check: 1 mm
Phasing - Phase Created: New Construction
Insulation - Insulation Thickness: 0 mm
Name (RAUTITAN_Sleeve PX:RTI S PX:...) | Elevation from Level (mm) | Language | Region Check | Region PID | DN (mm) | L1 (mm) | Volume (m3) | Description long | GTIN | PID | Weight
1086952 | -25.5 | Description EN | Check DE | PID DE | 12 | 23.7 | 0.00000312848 | REHAU Compression sleeve RAUTITAN PX 16 | 4007360361204 | 11600011001 | 7.6
1086956 | -25.5 | Description EN | Check DE | PID DE | 15 | 25 | 0.00000516767 | REHAU Compression sleeve RAUTITAN PX 20 | 4007360361211 | 11600021001 | 11
1086960 | -25.5 | Description EN | Check DE | PID DE | 15 | 25 | 0.00000516767 | REHAU Compression sleeve RAUTITAN PX 20 | 4007360361211 | 11600021001 | 11
1086964 | -25.5 | Description EN | Check DE | PID DE | 15 | 25 | 0.00000516767 | REHAU Compression sleeve RAUTITAN PX 20 | 4007360361211 | 11600021001 | 11
1086968 | -25.5 | Description EN | Check DE | PID DE | 20 | 27.2 | 0.0000087028 | REHAU Compression sleeve RAUTITAN PX 25 | 4007360361228 | 11600031001 | 15.828
1086972 | -25.5 | Description EN | Check DE | PID DE | 12 | 23.7 | 0.00000312848 | REHAU Compression sleeve RAUTITAN PX 16 | 4007360361204 | 11600011001 | 7.6
1086976 | -25.5 | Description EN | Check DE | PID DE | 12 | 23.7 | 0.00000312848 | REHAU Compression sleeve RAUTITAN PX 16 | 4007360361204 | 11600011001 | 7.6
1086980 | -25.5 | Description EN | Check DE | PID DE | 15 | 25 | 0.00000516767 | REHAU Compression sleeve RAUTITAN PX 20 | 4007360361211 | 11600021001 | 11
1086984 | -25.5 | Description EN | Check DE | PID DE | 12 | 23.7 | 0.00000312848 | REHAU Compression sleeve RAUTITAN PX 16 | 4007360361204 | 11600011001 | 7.6
1086988 | -25.5 | Description EN | Check DE | PID DE | 12 | 23.7 | 0.00000312848 | REHAU Compression sleeve RAUTITAN PX 16 | 4007360361204 | 11600011001 | 7.6
1086992 | -25.5 | Description EN | Check DE | PID DE | 12 | 23.7 | 0.00000312848 | REHAU Compression sleeve RAUTITAN PX 16 | 4007360361204 | 11600011001 | 7.6
1086996 | -25.5 | Description EN | Check DE | PID DE | 15 | 25 | 0.00000516767 | REHAU Compression sleeve RAUTITAN PX 20 | 4007360361211 | 11600021001 | 11
1087000 | -25.5 | Description EN | Check DE | PID DE | 12 | 23.7 | 0.00000312848 | REHAU Compression sleeve RAUTITAN PX 16 | 4007360361204 | 11600011001 | 7.6
1087004 | -25.5 | Description EN | Check DE | PID DE | 15 | 25 | 0.00000516767 | REHAU Compression sleeve RAUTITAN PX 20 | 4007360361211 | 11600021001 | 11
1087008 | -25.5 | Description EN | Check DE | PID DE | 12 | 23.7 | 0.00000312848 | REHAU Compression sleeve RAUTITAN PX 16 | 4007360361204 | 11600011001 | 7.6
1087012 | -25.5 | Description EN | Check DE | PID DE | 15 | 25 | 0.00000516767 | REHAU Compression sleeve RAUTITAN PX 20 | 4007360361211 | 11600021001 | 11
1087016 | -25.5 | Description EN | Check DE | PID DE | 12 | 23.7 | 0.00000312848 | REHAU Compression sleeve RAUTITAN PX 16 | 4007360361204 | 11600011001 | 7.6
1087020 | -25.5 | Description EN | Check DE | PID DE | 15 | 25 | 0.00000516767 | REHAU Compression sleeve RAUTITAN PX 20 | 4007360361211 | 11600021001 | 11
1238074 | 26.3 | Description EN | Check AU | PID AU | 12 | 23.7 | 0.00000312848 | REHAU Compression sleeve RAUTITAN PX 16 | 4007360361204 | 160001-001 | 7.6
1238077 | 26.3 | Description EN | Check AU | PID AU | 12 | 23.7 | 0.00000312848 | REHAU Compression sleeve RAUTITAN PX 16 | 4007360361204 | 160001-001 | 7.6
1238078 | 26.3 | Description EN | Check AU | PID AU | 12 | 23.7 | 0.00000312848 | REHAU Compression sleeve RAUTITAN PX 16 | 4007360361204 | 160001-001 | 7.6
1238319 | 26.3 | Description EN | Check AU | PID AU | 12 | 23.7 | 0.00000312848 | REHAU Compression sleeve RAUTITAN PX 16 | 4007360361204 | 160001-001 | 7.6
1238352 | 0 | Description EN | Check AU | PID AU | 12 | 23.7 | 0.00000312848 | REHAU Compression sleeve RAUTITAN PX 16 | 4007360361204 | 160001-001 | 7.6
1238355 | 0 | Description EN | Check AU | PID AU | 12 | 23.7 | 0.00000312848 | REHAU Compression sleeve RAUTITAN PX 16 | 4007360361204 | 160001-001 | 7.6
1238579 | 26.3 | Description EN | Check AU | PID AU | 12 | 23.7 | 0.00000312848 | REHAU Compression sleeve RAUTITAN PX 16 | 4007360361204 | 160001-001 | 7.6
1238585 | 0 | Description EN | Check AU | PID AU | 12 | 23.7 | 0.00000312848 | REHAU Compression sleeve RAUTITAN PX 16 | 4007360361204 | 160001-001 | 7.6
1238597 | 26.3 | Description EN | Check AU | PID AU | 12 | 23.7 | 0.00000312848 | REHAU Compression sleeve RAUTITAN PX 16 | 4007360361204 | 160001-001 | 7.6
1238605 | 0 | Description EN | Check AU | PID AU | 12 | 23.7 | 0.00000312848 | REHAU Compression sleeve RAUTITAN PX 16 | 4007360361204 | 160001-001 | 7.6
1238681 | -326.3 | Description EN | Check AU | PID AU | 12 | 23.7 | 0.00000312848 | REHAU Compression sleeve RAUTITAN PX 16 | 4007360361204 | 160001-001 | 7.6
1238707 | -326.3 | Description EN | Check AU | PID AU | 12 | 23.7 | 0.00000312848 | REHAU Compression sleeve RAUTITAN PX 16 | 4007360361204 | 160001-001 | 7.6
1238843 | 26.3 | Description EN | Check AU | PID AU | 12 | 23.7 | 0.00000312848 | REHAU Compression sleeve RAUTITAN PX 16 | 4007360361204 | 160001-001 | 7.6
1238893 | -326.3 | Description EN | Check AU | PID AU | 12 | 23.7 | 0.00000312848 | REHAU Compression sleeve RAUTITAN PX 16 | 4007360361204 | 160001-001 | 7.6
1238895 | -326.3 | Description EN | Check AU | PID AU | 12 | 23.7 | 0.00000312848 | REHAU Compression sleeve RAUTITAN PX 16 | 4007360361204 | 160001-001 | 7.6
1238954 | 26.3 | Description EN | Check AU | PID AU | 12 | 23.7 | 0.00000312848 | REHAU Compression sleeve RAUTITAN PX 16 | 4007360361204 | 160001-001 | 7.6
1238957 | 26.3 | Description EN | Check AU | PID AU | 12 | 23.7 | 0.00000312848 | REHAU Compression sleeve RAUTITAN PX 16 | 4007360361204 | 160001-001 | 7.6
1238958 | 26.3 | Description EN | Check AU | PID AU | 12 | 23.7 | 0.00000312848 | REHAU Compression sleeve RAUTITAN PX 16 | 4007360361204 | 160001-001 | 7.6
1238965 | 26.3 | Description EN | Check AU | PID AU | 12 | 23.7 | 0.00000312848 | REHAU Compression sleeve RAUTITAN PX 16 | 4007360361204 | 160001-001 | 7.6
1239028 | 201.2 | Description EN | Check AU | PID AU | 12 | 23.7 | 0.00000312848 | REHAU Compression sleeve RAUTITAN PX 16 | 4007360361204 | 160001-001 | 7.6
1239030 | 146.2 | Description EN | Check AU | PID AU | 12 | 23.7 | 0.00000312848 | REHAU Compression sleeve RAUTITAN PX 16 | 4007360361204 | 160001-001 | 7.6
1239230 | 0 | Description EN | PID AU | PID AU | 12 | 23.7 | 0.00000312848 | REHAU Compression sleeve RAUTITAN PX 16 | 4007360361204 | 160001-001 | 7.6
1239235 | 0 | Description EN | PID AU | PID AU | 12 | 23.7 | 0.00000312848 | REHAU Compression sleeve RAUTITAN PX 16 | 4007360361204 | 160001-001 | 7.6
1239245 | 1.2 | Description EN | Check AU | PID AU | 12 | 23.7 | 0.00000312848 | REHAU Compression sleeve RAUTITAN PX 16 | 4007360361204 | 160001-001 | 7.6
1239247 | -53.8 | Description EN | Check AU | PID AU | 12 | 23.7 | 0.00000312848 | REHAU Compression sleeve RAUTITAN PX 16 | 4007360361204 | 160001-001 | 7.6
1239303 | 0 | Description EN | PID AU | PID AU | 12 | 23.7 | 0.00000312848 | REHAU Compression sleeve RAUTITAN PX 16 | 4007360361204 | 160001-001 | 7.6
1239305 | 0 | Description EN | PID AU | PID AU | 12 | 23.7 | 0.00000312848 | REHAU Compression sleeve RAUTITAN PX 16 | 4007360361204 | 160001-001 | 7.6
1239441 | 0 | Description EN | Check AU | PID AU | 12 | 23.7 | 0.00000312848 | REHAU Compression sleeve RAUTITAN PX 16 | 4007360361204 | 160001-001 | 7.6
1239463 | 101.2 | Description EN | Check AU | PID AU | 12 | 23.7 | 0.00000312848 | REHAU Compression sleeve RAUTITAN PX 16 | 4007360361204 | 160001-001 | 7.6
1239566 | 0 | Description EN | Check AU | PID AU | 12 | 23.7 | 0.00000312848 | REHAU Compression sleeve RAUTITAN PX 16 | 4007360361204 | 160001-001 | 7.6
1239569 | 0 | Description EN | Check AU | PID AU | 12 | 23.7 | 0.00000312848 | REHAU Compression sleeve RAUTITAN PX 16 | 4007360361204 | 160001-001 | 7.6
1239595 | 201.2 | Description EN | Check AU | PID AU | 12 | 23.7 | 0.00000312848 | REHAU Compression sleeve RAUTITAN PX 16 | 4007360361204 | 160001-001 | 7.6
1239597 | 0 | Description EN | Check AU | PID AU | 12 | 23.7 | 0.00000312848 | REHAU Compression sleeve RAUTITAN PX 16 | 4007360361204 | 160001-001 | 7.6
1239659 | 201.2 | Description EN | Check AU | PID AU | 12 | 23.7 | 0.00000312848 | REHAU Compression sleeve RAUTITAN PX 16 | 4007360361204 | 160001-001 | 7.6
1239681 | 101.2 | Description EN | Check AU | PID AU | 12 | 23.7 | 0.00000312848 | REHAU Compression sleeve RAUTITAN PX 16 | 4007360361204 | 160001-001 | 7.6
1335387 | -23 | Description en | Check DE | PID DE | 12 | 23.7 | 0.00000312848 | N/A | 4007360361204 | 11600011001 | 7.6
1335390 | -24.3 | Description en | Check DE | PID DE | 12 | 23.7 | 0.00000312848 | N/A | 4007360361204 | 11600011001 | 7.6
1335392 | -24.3 | Description en | Check DE | PID DE | 12 | 23.7 | 0.00000312848 | N/A | 4007360361204 | 11600011001 | 7.6
1335394 | -24.3 | Description en | Check DE | PID DE | 12 | 23.7 | 0.00000312848 | N/A | 4007360361204 | 11600011001 | 7.6
1335396 | -24.3 | Description en | Check DE | PID DE | 12 | 23.7 | 0.00000312848 | N/A | 4007360361204 | 11600011001 | 7.6
1335398 | -22.3 | Description en | Check DE | PID DE | 12 | 23.7 | 0.00000312848 | N/A | 4007360361204 | 11600011001 | 7.6
1335400 | -24.8 | Description en | Check DE | PID DE | 12 | 23.7 | 0.00000312848 | N/A | 4007360361204 | 11600011001 | 7.6
1335402 | -24.8 | Description en | Check DE | PID DE | 12 | 23.7 | 0.00000312848 | N/A | 4007360361204 | 11600011001 | 7.6
1335404 | -27.2 | Description en | Check DE | PID DE | 12 | 23.7 | 0.00000312848 | N/A | 4007360361204 | 11600011001 | 7.6
1335406 | -27.6 | Description en | Check DE | PID DE | 12 | 23.7 | 0.00000312848 | N/A | 4007360361204 | 11600011001 | 7.6
1348565 | -25.5 | Description EN | Check DE | PID DE | 12 | 23.7 | 0.00000312848 | REHAU Compression sleeve RAUTITAN PX 16 | 4007360361204 | 11600011001 | 7.6
1354023 | -25.5 | Description EN | Check DE | PID DE | 12 | 23.7 | 0.00000312848 | REHAU Compression sleeve RAUTITAN PX 16 | 4007360361204 | 11600011001 | 7.6
1354063 | -25.5 | Description EN | Check DE | PID DE | 12 | 23.7 | 0.00000312848 | REHAU Compression sleeve RAUTITAN PX 16 | 4007360361204 | 11600011001 | 7.6
1354067 | -25.5 | Description EN | Check DE | PID DE | 15 | 25 | 0.00000516767 | REHAU Compression sleeve RAUTITAN PX 20 | 4007360361211 | 11600021001 | 11
1354071 | -25.5 | Description EN | Check DE | PID DE | 15 | 25 | 0.00000516767 | REHAU Compression sleeve RAUTITAN PX 20 | 4007360361211 | 11600021001 | 11

# IfcPipeFitting: RAUTITAN_Sleeve SDR 7,1:RTI S SDR 7,4 (12)
In: REHAU Starting view
Type - Material: Brass
Type - Other - Category: Pipe Fittings; Family Name: RAUTITAN_Sleeve SDR 7,1; T1: RTI Sleeve SDR 7,4; T2: RTI Sleeve SDR 7,4 D
Type - Constraints - Default Elevation: 0.0131234 mm
Type - Identity Data - REHAU Info: 2024.06.07-420668-420668; Type Name: RTI S SDR 7,4
Pset_EnvironmentalImpactIndicators - Reference: RAUTITAN_Sleeve SDR 7,1:RTI S SDR 7,4; sets with these values: 2
Other - Family: RAUTITAN_Sleeve SDR 7,1; Family and Type: RAUTITAN_Sleeve SDR 7,1: RTI S SDR 7,4; Type: RTI S SDR 7,4; Type Id: 1089418
Constraints - Elevation from Level: 0 mm; Level: REHAU Starting view; Moves With Nearby Elements: no
Data - Language: Description EN; Region Check: Check DE; Region PID: PID DE
Phasing - Phase Created: New Construction
Insulation - Insulation Thickness: 0 mm
Name (RAUTITAN_Sleeve SDR 7,1:RTI S SDR 7,4:...) | IsCustom | PID Check (mm) | DN (mm) | L1 (mm) | Volume (m3) | Description long | GTIN | PID | Weight
1443967 | no | 1 | 20 | 29 | 0.0000058041 | REHAU Compression sleeve RAUT. MX/LX +G 25 | 4007360377519 | 12596251402 | 46
1443969 | no | 1 | 20 | 29 | 0.0000058041 | REHAU Compression sleeve RAUT. MX/LX +G 25 | 4007360377519 | 12596251402 | 46
1443971 | no | 1 | 20 | 29 | 0.0000058041 | REHAU Compression sleeve RAUT. MX/LX +G 25 | 4007360377519 | 12596251402 | 46
1443973 | no | 1 | 25 | 34 | 0.0000131097 | REHAU Compression sleeve RAUT. MX/LX 32 | 4007360168698 | 11371661001 | 96
1443975 | no | 1 | 25 | 34 | 0.0000131097 | REHAU Compression sleeve RAUT. MX/LX 32 | 4007360168698 | 11371661001 | 96
1443977 | no | 1 | 32 | 37 | 0.0000199643 | REHAU Compression sleeve RAUT. MX/LX 40 | 4007360186487 | 11372961001 | 162
1443979 | no | 1 | 40 | 44 | 0.0000372872 | REHAU Compression sleeve RAUTITAN MX/LX 50 | 4007360031817 | 11397711002 | 293
1443981 | no | 1 | 50 | 53 | 0.0000553035 | REHAU Compression sleeve RAUTITAN MX/LX 63 | 4007360031824 | 11397811002 | 439
1444111 | no | 1 | 15 | 25 | 0.00000393937 | REHAU Compression sleeve RAUT. MX/LX 20 | 4007360031060 | 12596151002 | 28
1444113 | no | 1 | 15 | 25 | 0.00000393937 | REHAU Compression sleeve RAUT. MX/LX 20 | 4007360031060 | 12596151002 | 28
1444133 | yes | 0 | 12 | 24 | 0.00000332943 | REHAU Compression sleeve RAUT. MX/LX 16 | 4007360031053 | N/A | 25
1444135 | yes | 0 | 12 | 24 | 0.00000332943 | REHAU Compression sleeve RAUT. MX/LX 16 | 4007360031053 | N/A | 25

# IfcPipeFitting: RAUTITAN_T-piece_LX:RTI LX T DN (23)
In: REHAU Starting view
Type - Material: Br
Type - Other - Category: Pipe Fittings; Family Name: RAUTITAN_T-piece_LX; Max Sleeve: 32 mm; Min Sleeve: 12 mm; Sleeve LX: Sleeve : LX 7,4; Sleeve PX: Sleeve : LX 7,4; T1: RTI T-piece LX; T2: RTI T-piece LX DN1+3
Type - Constraints - Default Elevation: 0 mm
Type - Data - Language: Description en; Language Tender Text: Tender Text en; Region Check: Check DE; Region PID: PID DE; Region URL: Product URL DE; T3: RTI T-piece LX DN2; T4: Sleeve DN
Type - Identity Data - Assembly Code: D2090800; Classification Number: 23.60.30.11.14; Manufacturer: REHAU; Model: RAUTITAN; REHAU Info: 14.02.2024-420668-420668; Type Name: RTI LX T DN
Type - Materials and Finishes - Mat. Fitting: Br
Type - Mechanical - Loss Method: K Coefficient; K Coefficient: 1; K Coefficient Table: Converging/Diverging/Side Tee
Type - Pset_ManufacturerTypeInformation - Manufacturer: REHAU
Classification: D2090800 (Uniformat)
Pset_EnvironmentalImpactIndicators - Reference: RAUTITAN_T-piece_LX:RTI LX T DN; sets with these values: 2
Other - Sleeve DN1: Sleeve : LX 7,4; Sleeve DN2: Sleeve : LX 7,4; IsCustom: no; Family: RAUTITAN_T-piece_LX; Family and Type: RAUTITAN_T-piece_LX: RTI LX T DN; Sleeve DN3: Sleeve : LX 7,4; Type: RTI LX T DN; Type Id: 782580
Constraints - Elevation from Level: 0 mm; Level: REHAU Starting view
Data - PID Check: 1 mm
Dimensions - Area: 0.00465431 m2
Graphics - Use Annotation Scale: no
Identity Data - Sorting: 0; ETIM Class: EC003025; ETIM Class code: EC003025; ETIM Group: EG015540; ETIM Name: Fitting with 3 connections; Tender text: -
Mechanical - System Classification: Undefined
Phasing - Phase Created: New Construction
Insulation - Insulation Thickness: 0 mm
