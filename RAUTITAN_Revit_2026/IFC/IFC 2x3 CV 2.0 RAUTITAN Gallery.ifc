Properties of the parts of a building model (IFC2X3), part 3 of 9

# IfcFlowFitting: RAUTITAN_Sleeve PX2:RTI S PX 2 (14)
Name (RAUTITAN_Sleeve PX2:RTI S PX 2:...) | Area (m2) | DN (mm) | L1 (mm) | Volume (m3) | Description long | GTIN | PID | Weight
1442984 | 0.00205237 | 15 | 25 | 0.00000516767 | REHAU Compression sleeve RAUTITAN PX 20 | 4007360361211 | 11600021001 | 11
1442986 | 0.00280656 | 20 | 27.2 | 0.0000087028 | REHAU Compression sleeve RAUTITAN PX 25 | 4007360361228 | 11600031001 | 15.828
1442988 | 0.00280656 | 20 | 27.2 | 0.0000087028 | REHAU Compression sleeve RAUTITAN PX 25 | 4007360361228 | 11600031001 | 15.828
1442990 | 0.00280656 | 20 | 27.2 | 0.0000087028 | REHAU Compression sleeve RAUTITAN PX 25 | 4007360361228 | 11600031001 | 15.828
1442992 | 0.00447557 | 25 | 34 | 0.0000174355 | REHAU Compression sleeve RAUTITAN PX 32 | 4007360361235 | 11600041001 | 27.828
1442994 | 0.00447557 | 25 | 34 | 0.0000174355 | REHAU Compression sleeve RAUTITAN PX 32 | 4007360361235 | 11600041001 | 27.828
1442996 | 0.00631173 | 32 | 37.8 | 0.0000303041 | REHAU Compression sleeve RAUTITAN PX 40 | 4007360361242 | 11600051001 | 38.61
1442998 | 0.00864619 | 40 | 45 | 0.0000353695 | REHAU Compr. sleeve RAUTITAN PX stabil 50 | 4062178755416 | 11602061001 | 67.3
1443000 | 0.0130302 | 50 | 53 | 0.0000702282 | REHAU Compr. sleeve RAUTITAN PX stabil 63 | 4062178755423 | 11602071001 | 110.6
1443133 | 0.0015541 | 12 | 23.7 | 0.00000312848 | REHAU Compression sleeve RAUTITAN PX 16 | 4007360361204 | 11600011001 | 7.6
1443287 | 0.00205237 | 15 | 25 | 0.00000516767 | REHAU Compression sleeve RAUTITAN PX 20 | 4007360361211 | 11600021001 | 11

# IfcFlowFitting: RAUTITAN_Sleeve PX:DN1 (16)
In: REHAU Starting view
Type - Material: RAUTITAN PX
Type - Other - Category: Pipe Fittings; Family Name: RAUTITAN_Sleeve PX; T1: RTI Sleeve PX; T2: RTI Sleeve PX D
Type - Constraints - Default Elevation: 0 mm
Type - Identity Data - REHAU Info: 2024.06.11-420668-420668; Type Name: DN1
Pset_DistributionFlowElementCommon - Reference: RAUTITAN_Sleeve PX:DN1; sets with these values: 2
Other - IsCustom: no; Family: RAUTITAN_Sleeve PX; Family and Type: RAUTITAN_Sleeve PX: DN1; Type: DN1; Type Id: 1344532
Constraints - Level: REHAU Starting view; Moves With Nearby Elements: no; Elevation from Level: -43.3 mm
Data - Language: Description EN; PID Check: 1 mm; Region Check: Check DE; Region PID: PID DE
Phasing - Phase Created: New Construction
Insulation - Insulation Thickness: 0 mm
Name (RAUTITAN_Sleeve PX:DN1:...) | DN (mm) | L1 (mm) | Volume (m3) | Description long | GTIN | PID | Weight
1087041 | 12 | 23.7 | 0.00000312848 | REHAU Compression sleeve RAUTITAN PX 16 | 4007360361204 | 11600011001 | 7.6
1087043 | 12 | 23.7 | 0.00000312848 | REHAU Compression sleeve RAUTITAN PX 16 | 4007360361204 | 11600011001 | 7.6
1087047 | 12 | 23.7 | 0.00000312848 | REHAU Compression sleeve RAUTITAN PX 16 | 4007360361204 | 11600011001 | 7.6
1087049 | 12 | 23.7 | 0.00000312848 | REHAU Compression sleeve RAUTITAN PX 16 | 4007360361204 | 11600011001 | 7.6
1087053 | 15 | 25 | 0.00000516767 | REHAU Compression sleeve RAUTITAN PX 20 | 4007360361211 | 11600021001 | 11
1087055 | 15 | 25 | 0.00000516767 | REHAU Compression sleeve RAUTITAN PX 20 | 4007360361211 | 11600021001 | 11
1087059 | 15 | 25 | 0.00000516767 | REHAU Compression sleeve RAUTITAN PX 20 | 4007360361211 | 11600021001 | 11
1087061 | 15 | 25 | 0.00000516767 | REHAU Compression sleeve RAUTITAN PX 20 | 4007360361211 | 11600021001 | 11
1087065 | 20 | 27.2 | 0.0000087028 | REHAU Compression sleeve RAUTITAN PX 25 | 4007360361228 | 11600031001 | 15.828
1087067 | 20 | 27.2 | 0.0000087028 | REHAU Compression sleeve RAUTITAN PX 25 | 4007360361228 | 11600031001 | 15.828
1087071 | 20 | 27.2 | 0.0000087028 | REHAU Compression sleeve RAUTITAN PX 25 | 4007360361228 | 11600031001 | 15.828
1087073 | 20 | 27.2 | 0.0000087028 | REHAU Compression sleeve RAUTITAN PX 25 | 4007360361228 | 11600031001 | 15.828
1087077 | 12 | 23.7 | 0.00000312848 | REHAU Compression sleeve RAUTITAN PX 16 | 4007360361204 | 11600011001 | 7.6
1087079 | 15 | 25 | 0.00000516767 | REHAU Compression sleeve RAUTITAN PX 20 | 4007360361211 | 11600021001 | 11
1087083 | 15 | 25 | 0.00000516767 | REHAU Compression sleeve RAUTITAN PX 20 | 4007360361211 | 11600021001 | 11
1087085 | 12 | 23.7 | 0.00000312848 | REHAU Compression sleeve RAUTITAN PX 16 | 4007360361204 | 11600011001 | 7.6

# IfcFlowFitting: RAUTITAN_Sleeve PX:RTI S PX (68)
In: REHAU Starting view
Type - Material: RAUTITAN PX
Type - Other - Category: Pipe Fittings; Family Name: RAUTITAN_Sleeve PX; T1: RTI Sleeve PX; T2: RTI Sleeve PX D
Type - Constraints - Default Elevation: 0 mm
Type - Identity Data - REHAU Info: 2024.06.11-420668-420668; Type Name: RTI S PX
Pset_DistributionFlowElementCommon - Reference: RAUTITAN_Sleeve PX:RTI S PX; sets with these values: 2
Other - IsCustom: no; Family: RAUTITAN_Sleeve PX; Family and Type: RAUTITAN_Sleeve PX: RTI S PX; Type: RTI S PX; Type Id: 1191209
Constraints - Level: REHAU Starting view; Moves With Nearby Elements: no
Data - PID Check: 1 mm
Phasing - Phase Created: New Construction
Insulation - Insulation Thickness: 0 mm
Name (RAUTITAN_Sleeve PX:RTI S PX:...) | Elevation from Level (mm) | Language | Region Check | Region PID | DN (mm) | L1 (mm) | Volume (m3) | Description long | GTIN | PID | Weight
1086952 | -25.5 | Description EN | Check DE | PID DE | 12 | 23.7 | 0.00000312848 | REHAU Compression sleeve RAUTITAN PX 16 | 4007360361204 | 11600011001 | 7.6
1086956 | -25.5 | Description EN | Check DE | PID DE | 15 | 25 | 0.00000516767 | REHAU Compression sleeve RAUTITAN PX 20 | 4007360361211 | 11600021001 | 11
1086960 | -25.5 | Description EN | Check DE | PID DE | 15 | 25 | 0.00000516767 | REHAU Compression sleeve RAUTITAN PX 20 | 4007360361211 | 11600021001 | 11
1086964 | -25.5 | Description EN | Check DE | PID DE | 15 | 25 | 0.00000516767 | REHAU Compression sleeve RAUTITAN PX 20 | 4007360361211 | 11600021001 | 11
1086968 | -25.5 | Description EN | Check DE | PID DE | 20 | 27.2 | 0.0000087028 | REHAU Compression sleeve RAUTITAN PX 25 | 4007360361228 | 11600031001 | 15.828
1086972 | -25.5 | Description EN | Check DE | PID DE | 12 | 23.7 | 0.00000312848 | REHAU Compression sleeve RAUTITAN PX 16 | 4007360361204 | 11600011001 | 7.6
1086976 | -25.5 | Description EN | Check DE | PID DE | 12 | 23.7 | 0.00000312848 | REHAU Compression sleeve RAUTITAN PX 16 | 4007360361204 | 11600011001 | 7.6
1086980 | -25.5 | Description EN | Check DE | PID DE | 15 | 25 | 0.00000516767 | REHAU Compression sleeve RAUTITAN PX 20 | 4007360361211 | 11600021001 | 11
1086984 | -25.5 | Description EN | Check DE | PID DE | 12 | 23.7 | 0.00000312848 | REHAU Compression sleeve RAUTITAN PX 16 | 4007360361204 | 11600011001 | 7.6
1086988 | -25.5 | Description EN | Check DE | PID DE | 12 | 23.7 | 0.00000312848 | REHAU Compression sleeve RAUTITAN PX 16 | 4007360361204 | 11600011001 | 7.6
1086992 | -25.5 | Description EN | Check DE | PID DE | 12 | 23.7 | 0.00000312848 | REHAU Compression sleeve RAUTITAN PX 16 | 4007360361204 | 11600011001 | 7.6
1086996 | -25.5 | Description EN | Check DE | PID DE | 15 | 25 | 0.00000516767 | REHAU Compression sleeve RAUTITAN PX 20 | 4007360361211 | 11600021001 | 11
1087000 | -25.5 | Description EN | Check DE | PID DE | 12 | 23.7 | 0.00000312848 | REHAU Compression sleeve RAUTITAN PX 16 | 4007360361204 | 11600011001 | 7.6
1087004 | -25.5 | Description EN | Check DE | PID DE | 15 | 25 | 0.00000516767 | REHAU Compression sleeve RAUTITAN PX 20 | 4007360361211 | 11600021001 | 11
1087008 | -25.5 | Description EN | Check DE | PID DE | 12 | 23.7 | 0.00000312848 | REHAU Compression sleeve RAUTITAN PX 16 | 4007360361204 | 11600011001 | 7.6
1087012 | -25.5 | Description EN | Check DE | PID DE | 15 | 25 | 0.00000516767 | REHAU Compression sleeve RAUTITAN PX 20 | 4007360361211 | 11600021001 | 11
1087016 | -25.5 | Description EN | Check DE | PID DE | 12 | 23.7 | 0.00000312848 | REHAU Compression sleeve RAUTITAN PX 16 | 4007360361204 | 11600011001 | 7.6
1087020 | -25.5 | Description EN | Check DE | PID DE | 15 | 25 | 0.00000516767 | REHAU Compression sleeve RAUTITAN PX 20 | 4007360361211 | 11600021001 | 11
1238074 | 26.3 | Description EN | Check AU | PID AU | 12 | 23.7 | 0.00000312848 | REHAU Compression sleeve RAUTITAN PX 16 | 4007360361204 | 160001-001 | 7.6
1238077 | 26.3 | Description EN | Check AU | PID AU | 12 | 23.7 | 0.00000312848 | REHAU Compression sleeve RAUTITAN PX 16 | 4007360361204 | 160001-001 | 7.6
1238078 | 26.3 | Description EN | Check AU | PID AU | 12 | 23.7 | 0.00000312848 | REHAU Compression sleeve RAUTITAN PX 16 | 4007360361204 | 160001-001 | 7.6
1238319 | 26.3 | Description EN | Check AU | PID AU | 12 | 23.7 | 0.00000312848 | REHAU Compression sleeve RAUTITAN PX 16 | 4007360361204 | 160001-001 | 7.6
1238352 | 0 | Description EN | Check AU | PID AU | 12 | 23.7 | 0.00000312848 | REHAU Compression sleeve RAUTITAN PX 16 | 4007360361204 | 160001-001 | 7.6
1238355 | 0 | Description EN | Check AU | PID AU | 12 | 23.7 | 0.00000312848 | REHAU Compression sleeve RAUTITAN PX 16 | 4007360361204 | 160001-001 | 7.6
1238579 | 26.3 | Description EN | Check AU | PID AU | 12 | 23.7 | 0.00000312848 | REHAU Compression sleeve RAUTITAN PX 16 | 4007360361204 | 160001-001 | 7.6
1238585 | 0 | Description EN | Check AU | PID AU | 12 | 23.7 | 0.00000312848 | REHAU Compression sleeve RAUTITAN PX 16 | 4007360361204 | 160001-001 | 7.6
1238597 | 26.3 | Description EN | Check AU | PID AU | 12 | 23.7 | 0.00000312848 | REHAU Compression sleeve RAUTITAN PX 16 | 4007360361204 | 160001-001 | 7.6
1238605 | 0 | Description EN | Check AU | PID AU | 12 | 23.7 | 0.00000312848 | REHAU Compression sleeve RAUTITAN PX 16 | 4007360361204 | 160001-001 | 7.6
1238681 | -326.3 | Description EN | Check AU | PID AU | 12 | 23.7 | 0.00000312848 | REHAU Compression sleeve RAUTITAN PX 16 | 4007360361204 | 160001-001 | 7.6
1238707 | -326.3 | Description EN | Check AU | PID AU | 12 | 23.7 | 0.00000312848 | REHAU Compression sleeve RAUTITAN PX 16 | 4007360361204 | 160001-001 | 7.6
1238843 | 26.3 | Description EN | Check AU | PID AU | 12 | 23.7 | 0.00000312848 | REHAU Compression sleeve RAUTITAN PX 16 | 4007360361204 | 160001-001 | 7.6
1238893 | -326.3 | Description EN | Check AU | PID AU | 12 | 23.7 | 0.00000312848 | REHAU Compression sleeve RAUTITAN PX 16 | 4007360361204 | 160001-001 | 7.6
1238895 | -326.3 | Description EN | Check AU | PID AU | 12 | 23.7 | 0.00000312848 | REHAU Compression sleeve RAUTITAN PX 16 | 4007360361204 | 160001-001 | 7.6
1238954 | 26.3 | Description EN | Check AU | PID AU | 12 | 23.7 | 0.00000312848 | REHAU Compression sleeve RAUTITAN PX 16 | 4007360361204 | 160001-001 | 7.6
1238957 | 26.3 | Description EN | Check AU | PID AU | 12 | 23.7 | 0.00000312848 | REHAU Compression sleeve RAUTITAN PX 16 | 4007360361204 | 160001-001 | 7.6
1238958 | 26.3 | Description EN | Check AU | PID AU | 12 | 23.7 | 0.00000312848 | REHAU Compression sleeve RAUTITAN PX 16 | 4007360361204 | 160001-001 | 7.6
1238965 | 26.3 | Description EN | Check AU | PID AU | 12 | 23.7 | 0.00000312848 | REHAU Compression sleeve RAUTITAN PX 16 | 4007360361204 | 160001-001 | 7.6
1239028 | 201.2 | Description EN | Check AU | PID AU | 12 | 23.7 | 0.00000312848 | REHAU Compression sleeve RAUTITAN PX 16 | 4007360361204 | 160001-001 | 7.6
1239030 | 146.2 | Description EN | Check AU | PID AU | 12 | 23.7 | 0.00000312848 | REHAU Compression sleeve RAUTITAN PX 16 | 4007360361204 | 160001-001 | 7.6
1239230 | 0 | Description EN | PID AU | PID AU | 12 | 23.7 | 0.00000312848 | REHAU Compression sleeve RAUTITAN PX 16 | 4007360361204 | 160001-001 | 7.6
1239235 | 0 | Description EN | PID AU | PID AU | 12 | 23.7 | 0.00000312848 | REHAU Compression sleeve RAUTITAN PX 16 | 4007360361204 | 160001-001 | 7.6
1239245 | 1.2 | Description EN | Check AU | PID AU | 12 | 23.7 | 0.00000312848 | REHAU Compression sleeve RAUTITAN PX 16 | 4007360361204 | 160001-001 | 7.6
1239247 | -53.8 | Description EN | Check AU | PID AU | 12 | 23.7 | 0.00000312848 | REHAU Compression sleeve RAUTITAN PX 16 | 4007360361204 | 160001-001 | 7.6
1239303 | 0 | Description EN | PID AU | PID AU | 12 | 23.7 | 0.00000312848 | REHAU Compression sleeve RAUTITAN PX 16 | 4007360361204 | 160001-001 | 7.6
1239305 | 0 | Description EN | PID AU | PID AU | 12 | 23.7 | 0.00000312848 | REHAU Compression sleeve RAUTITAN PX 16 | 4007360361204 | 160001-001 | 7.6
1239441 | 0 | Description EN | Check AU | PID AU | 12 | 23.7 | 0.00000312848 | REHAU Compression sleeve RAUTITAN PX 16 | 4007360361204 | 160001-001 | 7.6
1239463 | 101.2 | Description EN | Check AU | PID AU | 12 | 23.7 | 0.00000312848 | REHAU Compression sleeve RAUTITAN PX 16 | 4007360361204 | 160001-001 | 7.6
1239566 | 0 | Description EN | Check AU | PID AU | 12 | 23.7 | 0.00000312848 | REHAU Compression sleeve RAUTITAN PX 16 | 4007360361204 | 160001-001 | 7.6
1239569 | 0 | Description EN | Check AU | PID AU | 12 | 23.7 | 0.00000312848 | REHAU Compression sleeve RAUTITAN PX 16 | 4007360361204 | 160001-001 | 7.6
1239595 | 201.2 | Description EN | Check AU | PID AU | 12 | 23.7 | 0.00000312848 | REHAU Compression sleeve RAUTITAN PX 16 | 4007360361204 | 160001-001 | 7.6
1239597 | 0 | Description EN | Check AU | PID AU | 12 | 23.7 | 0.00000312848 | REHAU Compression sleeve RAUTITAN PX 16 | 4007360361204 | 160001-001 | 7.6
1239659 | 201.2 | Description EN | Check AU | PID AU | 12 | 23.7 | 0.00000312848 | REHAU Compression sleeve RAUTITAN PX 16 | 4007360361204 | 160001-001 | 7.6
1239681 | 101.2 | Description EN | Check AU | PID AU | 12 | 23.7 | 0.00000312848 | REHAU Compression sleeve RAUTITAN PX 16 | 4007360361204 | 160001-001 | 7.6
1335387 | -23 | Description en | Check DE | PID DE | 12 | 23.7 | 0.00000312848 | N/A | 4007360361204 | 11600011001 | 7.6
1335390 | -24.3 | Description en | Check DE | PID DE | 12 | 23.7 | 0.00000312848 | N/A | 4007360361204 | 11600011001 | 7.6
1335392 | -24.3 | Description en | Check DE | PID DE | 12 | 23.7 | 0.00000312848 | N/A | 4007360361204 | 11600011001 | 7.6
1335394 | -24.3 | Description en | Check DE | PID DE | 12 | 23.7 | 0.00000312848 | N/A | 4007360361204 | 11600011001 | 7.6
1335396 | -24.3 | Description en | Check DE | PID DE | 12 | 23.7 | 0.00000312848 | N/A | 4007360361204 | 11600011001 | 7.6
1335398 | -22.3 | Description en | Check DE | PID DE | 12 | 23.7 | 0.00000312848 | N/A | 4007360361204 | 11600011001 | 7.6
1335400 | -24.8 | Description en | Check DE | PID DE | 12 | 23.7 | 0.00000312848 | N/A | 4007360361204 | 11600011001 | 7.6
1335402 | -24.8 | Description en | Check DE | PID DE | 12 | 23.7 | 0.00000312848 | N/A | 4007360361204 | 11600011001 | 7.6
1335404 | -27.2 | Description en | Check DE | PID DE | 12 | 23.7 | 0.00000312848 | N/A | 4007360361204 | 11600011001 | 7.6
1335406 | -27.6 | Description en | Check DE | PID DE | 12 | 23.7 | 0.00000312848 | N/A | 4007360361204 | 11600011001 | 7.6
1348565 | -25.5 | Description EN | Check DE | PID DE | 12 | 23.7 | 0.00000312848 | REHAU Compression sleeve RAUTITAN PX 16 | 4007360361204 | 11600011001 | 7.6
1354023 | -25.5 | Description EN | Check DE | PID DE | 12 | 23.7 | 0.00000312848 | REHAU Compression sleeve RAUTITAN PX 16 | 4007360361204 | 11600011001 | 7.6
1354063 | -25.5 | Description EN | Check DE | PID DE | 12 | 23.7 | 0.00000312848 | REHAU Compression sleeve RAUTITAN PX 16 | 4007360361204 | 11600011001 | 7.6
1354067 | -25.5 | Description EN | Check DE | PID DE | 15 | 25 | 0.00000516767 | REHAU Compression sleeve RAUTITAN PX 20 | 4007360361211 | 11600021001 | 11
1354071 | -25.5 | Description EN | Check DE | PID DE | 15 | 25 | 0.00000516767 | REHAU Compression sleeve RAUTITAN PX 20 | 4007360361211 | 11600021001 | 11

# IfcFlowFitting: RAUTITAN_Sleeve SDR 7,1:RTI S SDR 7,4 (12)
In: REHAU Starting view
Type - Material: Brass
Type - Other - Category: Pipe Fittings; Family Name: RAUTITAN_Sleeve SDR 7,1; T1: RTI Sleeve SDR 7,4; T2: RTI Sleeve SDR 7,4 D
Type - Constraints - Default Elevation: 0.0131234 mm
Type - Identity Data - REHAU Info: 2024.06.07-420668-420668; Type Name: RTI S SDR 7,4
Pset_DistributionFlowElementCommon - Reference: RAUTITAN_Sleeve SDR 7,1:RTI S SDR 7,4; sets with these values: 2
Other - Family: RAUTITAN_Sleeve SDR 7,1; Family and Type: RAUTITAN_Sleeve SDR 7,1: RTI S SDR 7,4; Type: RTI S SDR 7,4; Type Id: 1089418
Constraints - Elevation from Level: 0 mm; Level: REHAU Starting view; Moves With Nearby Elements: no
Data - Language: Description EN; Region Check: Check DE; Region PID: PID DE
Phasing - Phase Created: New Construction
Insulation - Insulation Thickness: 0 mm
Name (RAUTITAN_Sleeve SDR 7,1:RTI S SDR 7,4:...) | IsCustom | PID Check (mm) | DN (mm) | L1 (mm) | Volume (m3) | Description long | GTIN | PID | Weight
1443967 | no | 1 | 20 | 29 | 0.0000058041 | REHAU Compression sleeve RAUT. MX/LX +G 25 | 4007360377519 | 12596251402 | 46
1443969 | no | 1 | 20 | 29 | 0.0000058041 | REHAU Compression sleeve RAUT. MX/LX +G 25 | 4007360377519 | 12596251402 | 46
1443971 | no | 1 | 20 | 29 | 0.0000058041 | REHAU Compression sleeve RAUT. MX/LX +G 25 | 4007360377519 | 12596251402 | 46
1443973 | no | 1 | 25 | 34 | 0.0000131097 | REHAU Compression sleeve RAUT. MX/LX 32 | 4007360168698 | 11371661001 | 96
1443975 | no | 1 | 25 | 34 | 0.0000131097 | REHAU Compression sleeve RAUT. MX/LX 32 | 4007360168698 | 11371661001 | 96
1443977 | no | 1 | 32 | 37 | 0.0000199643 | REHAU Compression sleeve RAUT. MX/LX 40 | 4007360186487 | 11372961001 | 162
1443979 | no | 1 | 40 | 44 | 0.0000372872 | REHAU Compression sleeve RAUTITAN MX/LX 50 | 4007360031817 | 11397711002 | 293
1443981 | no | 1 | 50 | 53 | 0.0000553035 | REHAU Compression sleeve RAUTITAN MX/LX 63 | 4007360031824 | 11397811002 | 439
1444111 | no | 1 | 15 | 25 | 0.00000393937 | REHAU Compression sleeve RAUT. MX/LX 20 | 4007360031060 | 12596151002 | 28
1444113 | no | 1 | 15 | 25 | 0.00000393937 | REHAU Compression sleeve RAUT. MX/LX 20 | 4007360031060 | 12596151002 | 28
1444133 | yes | 0 | 12 | 24 | 0.00000332943 | REHAU Compression sleeve RAUT. MX/LX 16 | 4007360031053 | N/A | 25
1444135 | yes | 0 | 12 | 24 | 0.00000332943 | REHAU Compression sleeve RAUT. MX/LX 16 | 4007360031053 | N/A | 25

# IfcFlowFitting: RAUTITAN_T-piece_LX:RTI LX T DN (23)
In: REHAU Starting view
Type - Material: Br
Type - Other - Category: Pipe Fittings; Family Name: RAUTITAN_T-piece_LX; Max Sleeve: 32 mm; Min Sleeve: 12 mm; Sleeve LX: Sleeve : LX 7,4; Sleeve PX: Sleeve : LX 7,4; T1: RTI T-piece LX; T2: RTI T-piece LX DN1+3
Type - Constraints - Default Elevation: 0 mm
Type - Data - Language: Description en; Language Tender Text: Tender Text en; Region Check: Check DE; Region PID: PID DE; Region URL: Product URL DE; T3: RTI T-piece LX DN2; T4: Sleeve DN
Type - Identity Data - Assembly Code: D2090800; Classification Number: 23.60.30.11.14; Manufacturer: REHAU; Model: RAUTITAN; REHAU Info: 14.02.2024-420668-420668; Type Name: RTI LX T DN
Type - Materials and Finishes - Mat. Fitting: Br
Type - Mechanical - Loss Method: K Coefficient; K Coefficient: 1; K Coefficient Table: Converging/Diverging/Side Tee
Type - Pset_ManufacturerTypeInformation - Manufacturer: REHAU
Classification: D2090800 (Uniformat)
Pset_DistributionFlowElementCommon - Reference: RAUTITAN_T-piece_LX:RTI LX T DN; sets with these values: 2
Other - Sleeve DN1: Sleeve : LX 7,4; Sleeve DN2: Sleeve : LX 7,4; IsCustom: no; Family: RAUTITAN_T-piece_LX; Family and Type: RAUTITAN_T-piece_LX: RTI LX T DN; Sleeve DN3: Sleeve : LX 7,4; Type: RTI LX T DN; Type Id: 782580
Constraints - Elevation from Level: 0 mm; Level: REHAU Starting view
Data - PID Check: 1 mm
Dimensions - Area: 0.00465431 m2
Graphics - Use Annotation Scale: no
Identity Data - Sorting: 0; ETIM Class: EC003025; ETIM Class code: EC003025; ETIM Group: EG015540; ETIM Name: Fitting with 3 connections; Tender text: -
Mechanical - System Classification: Undefined
Phasing - Phase Created: New Construction
Insulation - Insulation Thickness: 0 mm
Name (RAUTITAN_T-piece_LX:RTI LX T DN:...) | V1 | V2 | L4 (mm) | Di1 (mm) | Di2 (mm) | Di3 (mm) | DN1 (mm) | DN2 (mm) | DN3 (mm) | Maximum Size (mm) | Minimum Size (mm) | Size = Overall Size | Volume (m3) | Description long | GTIN | PID | Product Group | Product URL | Weight
906051 | yes | no | 27.6 | 15.2 | 15.2 | 15.2 | 20 | 20 | 20 | 20 | 20 | 20 mmø-20 mmø-20 mmø | 0.000038145 | REHAU T-piece RAUTITAN LX +G 25 - 25 - 25 | 4007360542832 | 13129511001 | 2013 | https://oxomi.com/p/3000126/datasheet/-/13129511001 | 0.217
907062 | yes | no | 33 | 20 | 20 | 20 | 25 | 25 | 25 | 25 | 25 | 25 mmø-25 mmø-25 mmø | 0.0000524202 | REHAU T-piece RAUTITAN LX +G 32 - 32 - 32 | 4007360542849 | 13129521001 | 2014 | https://oxomi.com/p/3000126/datasheet/-/13129521001 | 0.39
931723 | yes | no | 43 | 23 | 23 | 23 | 32 | 32 | 32 | 32 | 32 | 32 mmø-32 mmø-32 mmø | 0.00010493 | REHAU T-piece RAUTITAN LX +G 40 - 40 - 40 | 4007360542856 | 13129531001 | 2015 | https://oxomi.com/p/3000126/datasheet/-/13129531001 | 0.8
931823 | yes | no | 46 | 30 | 30 | 30 | 40 | 40 | 40 | 40 | 40 | 40 mmø-40 mmø-40 mmø | 0.000154605 | REHAU T-piece RAUTITAN LX 50 - 50 - 50 | 4007360459802 | 11680751001 | 2004 | https://oxomi.com/p/3000126/datasheet/-/11680751001 | 1.19
931939 | yes | no | 54.5 | 39 | 39 | 39 | 50 | 50 | 50 | 50 | 50 | 50 mmø-50 mmø-50 mmø | 0.000256231 | REHAU T-piece RAUTITAN LX 63 - 63 - 63 | 4007360459864 | 11680811001 | 2006 | https://oxomi.com/p/3000126/datasheet/-/11680811001 | 2.2
932075 | yes | no | 24.2 | 12.5 | 12.5 | 12.5 | 15 | 15 | 15 | 15 | 15 | 15 mmø-15 mmø-15 mmø | 0.0000202194 | REHAU T-piece RAUTITAN LX +G 20 - 20 - 20 | 4007360542825 | 13129491001 | 2012 | https://oxomi.com/p/3000126/datasheet/-/13129491001 | 0.13
932169 | yes | no | 27.2 | 15.2 | 12.5 | 15.2 | 20 | 15 | 20 | 20 | 15 | 20 mmø-20 mmø-15 mmø | 0.0000306317 | REHAU T-piece RAUTITAN LX +G 25 - 20 - 25 | 4007360542900 | 13129581001 | 2020 | https://oxomi.com/p/3000126/datasheet/-/13129581001 | 0.19
932177 | yes | no | 30.6 | 20 | 15.2 | 20 | 25 | 20 | 25 | 25 | 20 | 25 mmø-25 mmø-20 mmø | 0.0000470933 | REHAU T-piece RAUTITAN LX +G 32 - 25 - 32 | 4007360542924 | 13129601001 | 2021 | https://oxomi.com/p/3000126/datasheet/-/13129601001 | 0.34
932185 | yes | no | 38.5 | 23 | 20 | 23 | 32 | 25 | 32 | 32 | 25 | 32 mmø-32 mmø-25 mmø | 0.0000855319 | REHAU T-piece RAUTITAN LX 40 - 32 - 40 | 4007360459536 | 11680671001 | 1997 | https://oxomi.com/p/3000126/datasheet/-/11680671001 | 0.646
932193 | yes | no | 46 | 30 | 23 | 30 | 40 | 32 | 40 | 40 | 32 | 40 mmø-40 mmø-32 mmø | 0.000135864 | REHAU T-piece RAUTITAN LX 50 - 40 - 50 | 4007360459796 | 11680741001 | 2003 | https://oxomi.com/p/3000126/datasheet/-/11680741001 | 1.036
932201 | yes | no | 53 | 39 | 30 | 39 | 50 | 40 | 50 | 50 | 40 | 50 mmø-50 mmø-40 mmø | 0.000219423 | REHAU T-piece RAUTITAN LX 63 - 50 - 63 | 4007360459857 | 11680801001 | 2009 | https://oxomi.com/p/3000126/datasheet/-/11680801001 | 1.645
932529 | yes | no | 30.2 | 20 | 12.5 | 20 | 25 | 15 | 25 | 25 | 15 | 25 mmø-25 mmø-15 mmø | 0.0000397954 | REHAU T-piece RAUTITAN LX 32 - 20 - 32 | 4007360459406 | 11680541001 | 1990 | https://oxomi.com/p/3000126/datasheet/-/11680541001 | 0.29
932537 | yes | no | 36.2 | 23 | 15.2 | 23 | 32 | 20 | 32 | 32 | 20 | 32 mmø-32 mmø-20 mmø | 0.0000793327 | REHAU T-piece RAUTITAN LX 40 - 25 - 40 | 4007360459512 | 11680651001 | 1995 | https://oxomi.com/p/3000126/datasheet/-/11680651001 | 0.642
932545 | yes | no | 42 | 30 | 20 | 30 | 40 | 25 | 40 | 40 | 25 | 40 mmø-40 mmø-25 mmø | 0.000115932 | REHAU T-piece RAUTITAN LX 50 - 32 - 50 | 4007360459789 | 11680731001 | 2002 | https://oxomi.com/p/3000126/datasheet/-/11680731001 | 0.84
932553 | yes | no | 50 | 39 | 20 | 39 | 50 | 25 | 50 | 50 | 25 | 50 mmø-50 mmø-25 mmø | 0.00017642 | REHAU T-piece RAUTITAN LX 63 - 32 - 63 | 4007360459833 | 11680781001 | 2007 | https://oxomi.com/p/3000126/datasheet/-/11680781001 | 1.45
943224 | yes | no | 45.2 | 30 | 15.2 | 30 | 40 | 20 | 40 | 40 | 20 | 40 mmø-40 mmø-20 mmø | 0.000109861 | REHAU T-piece RAUTITAN LX 50 - 25 - 50 | 4007360459765 | 11680711001 | 2000 | https://oxomi.com/p/3000126/datasheet/-/11680711001 | 0.805
943302 | yes | no | 24.7 | 12.5 | 15.2 | 12.5 | 15 | 20 | 15 | 20 | 15 | 20 mmø-15 mmø-15 mmø | 0.0000266215 | REHAU T-piece RAUTITAN LX 20 - 25 - 20 | 4007360459253 | 11680391001 | 1979 | https://oxomi.com/p/3000126/datasheet/-/11680391001 | 0.173
943413 | no | yes | 27.2 | 15.2 | 12.5 | 12.5 | 20 | 15 | 15 | 20 | 15 | 20 mmø-15 mmø-15 mmø | 0.000026918 | REHAU T-piece RAUTITAN LX +G 25 - 20 - 20 | 4007360542979 | 13129651001 | 2026 | https://oxomi.com/p/3000126/datasheet/-/13129651001 | 0.178
943421 | no | yes | 30.6 | 20 | 15.2 | 15.2 | 25 | 20 | 20 | 25 | 20 | 25 mmø-20 mmø-20 mmø | 0.0000429953 | REHAU T-piece RAUTITAN LX +G 32 - 25 - 25 | 4007360542986 | 13129661001 | 2027 | https://oxomi.com/p/3000126/datasheet/-/13129661001 | 0.299
943429 | no | yes | 38.5 | 23 | 20 | 20 | 32 | 25 | 25 | 32 | 25 | 32 mmø-25 mmø-25 mmø | 0.0000723559 | REHAU T-piece RAUTITAN LX 40 - 32 - 40 | 4007360459529 | 11680661001 | 1996 | https://oxomi.com/p/3000126/datasheet/-/11680661001 | 0.526
943727 | no | yes | 27.2 | 15.2 | 15.2 | 12.5 | 20 | 20 | 15 | 20 | 15 | 20 mmø-15 mmø-20 mmø | 0.0000344125 | REHAU T-piece RAUTITAN LX +G 25 - 25 - 20 | 4007360542962 | 13129641001 | 2025 | https://oxomi.com/p/3000126/datasheet/-/13129641001 | 0.218
943735 | no | yes | 31.4 | 20 | 20 | 15.2 | 25 | 25 | 20 | 25 | 20 | 25 mmø-20 mmø-25 mmø | 0.0000489107 | REHAU T-piece RAUTITAN LX 32 - 32 - 25 | 4007360459451 | 11680591001 | 1993 | https://oxomi.com/p/3000126/datasheet/-/11680591001 | 0.356
943919 | no | yes | 42 | 30 | 20 | 23 | 40 | 25 | 32 | 40 | 25 | 40 mmø-32 mmø-25 mmø | 0.000107112 | REHAU T-piece RAUTITAN LX 50 - 32 - 40 | 4007360459772 | 11680721001 | 1998 | https://oxomi.com/p/3000126/datasheet/-/11680721001 | 0.88

# IfcFlowFitting: RAUTITAN_T-piece_LX:RTI LX T DN (13)
In: REHAU Starting view
Type - Material: Br, Error
Type - Other - Category: Pipe Fittings; Family Name: RAUTITAN_T-piece_LX; Max Sleeve: 32 mm; Min Sleeve: 12 mm; Sleeve LX: Sleeve : LX 7,4; Sleeve PX: Sleeve : LX 7,4; T1: RTI T-piece LX; T2: RTI T-piece LX DN1+3
Type - Constraints - Default Elevation: 0 mm
Type - Data - Language: Description en; Language Tender Text: Tender Text en; Region Check: Check DE; Region PID: PID DE; Region URL: Product URL DE; T3: RTI T-piece LX DN2; T4: Sleeve DN
Type - Identity Data - Assembly Code: D2090800; Classification Number: 23.60.30.11.14; Manufacturer: REHAU; Model: RAUTITAN; REHAU Info: 14.02.2024-420668-420668; Type Name: RTI LX T DN
Type - Materials and Finishes - Mat. Fitting: Br
Type - Mechanical - Loss Method: K Coefficient; K Coefficient: 1; K Coefficient Table: Converging/Diverging/Side Tee
Type - Pset_ManufacturerTypeInformation - Manufacturer: REHAU
Classification: D2090800 (Uniformat)
Pset_DistributionFlowElementCommon - Reference: RAUTITAN_T-piece_LX:RTI LX T DN; sets with these values: 2
Other - IsCustom: yes; Sleeve DN1: Sleeve : LX 7,4; Sleeve DN2: Sleeve : LX 7,4; Family: RAUTITAN_T-piece_LX; Family and Type: RAUTITAN_T-piece_LX: RTI LX T DN; Sleeve DN3: Sleeve : LX 7,4; Type: RTI LX T DN; Type Id: 782580
Constraints - Elevation from Level: 0 mm; Level: REHAU Starting view
Data - PID Check: 0 mm
Dimensions - Area: 0.00465431 m2; Volume: 0.0000321717 m3
Graphics - Use Annotation Scale: no
Identity Data - Sorting: 0; ETIM Class: EC003025; ETIM Class code: EC003025; ETIM Group: EG015540; ETIM Name: Fitting with 3 connections; PID: -; Tender text: -
Mechanical - System Classification: Undefined
Phasing - Phase Created: New Construction
Insulation - Insulation Thickness: 0 mm
Name (RAUTITAN_T-piece_LX:RTI LX T DN:...) | L4 (mm) | V1 | V2 | Di1 (mm) | Di2 (mm) | Di3 (mm) | DN1 (mm) | DN2 (mm) | DN3 (mm) | Maximum Size (mm) | Minimum Size (mm) | Size = Overall Size | Description long | GTIN | Product Group | Product URL | Weight
905539 | 20 | yes | no | 6.6 | 6.6 | 6.6 | 10 | 10 | 10 | 10 | 10 | 10 mmø-10 mmø-10 mmø | REHAU T-piece RAUTITAN LX 12 - 12 - 12 | 4007360557409 | 1970 | https://oxomi.com/p/3000126/datasheet/-/11681971001 | 0.06
905870 | 22.3 | yes | no | 9.9 | 9.9 | 9.9 | 12 | 12 | 12 | 12 | 12 | 12 mmø-12 mmø-12 mmø | REHAU T-piece RAUTITAN LX +G 16 - 16 - 16 | 4007360542818 | 2011 | https://oxomi.com/p/3000126/datasheet/-/13129481001 | 0.087
932161 | 22 | yes | no | 9.9 | 6.6 | 9.9 | 12 | 10 | 12 | 12 | 10 | 12 mmø-12 mmø-10 mmø | REHAU T-piece RAUTITAN LX 16 - 12 - 16 | 4007360468835 | 1972 | https://oxomi.com/p/3000126/datasheet/-/11680281001 | 0.07
932209 | 23.7 | yes | no | 12.5 | 9.9 | 12.5 | 15 | 12 | 15 | 15 | 12 | 15 mmø-15 mmø-12 mmø | REHAU T-piece RAUTITAN LX +G 20 - 16 - 20 | 4007360542887 | 2018 | https://oxomi.com/p/3000126/datasheet/-/13129561001 | 0.11
932521 | 26.7 | yes | no | 15.2 | 9.9 | 15.2 | 20 | 12 | 20 | 20 | 12 | 20 mmø-20 mmø-12 mmø | REHAU T-piece RAUTITAN LX +G 25 - 16 - 25 | 4007360542894 | 2019 | https://oxomi.com/p/3000126/datasheet/-/13129571001 | 0.16
932561 | 23.4 | yes | no | 12.5 | 6.6 | 12.5 | 15 | 10 | 15 | 15 | 10 | 15 mmø-15 mmø-10 mmø | REHAU T-piece RAUTITAN LX 20 - 12 - 20 | 4007360468859 | 1975 | https://oxomi.com/p/3000126/datasheet/-/11680331001 | 0.108
943294 | 22.5 | yes | no | 9.9 | 12.5 | 9.9 | 12 | 15 | 12 | 15 | 12 | 15 mmø-12 mmø-12 mmø | REHAU T-piece RAUTITAN LX 16 - 20 - 16 | 4007360459192 | 1974 | https://oxomi.com/p/3000126/datasheet/-/11680311001 | 0.106
943405 | 22 | no | yes | 9.9 | 6.6 | 6.6 | 12 | 10 | 10 | 12 | 10 | 12 mmø-10 mmø-10 mmø | REHAU T-piece RAUTITAN LX 16 - 12 - 12 | 4007360557416 | 1971 | https://oxomi.com/p/3000126/datasheet/-/11681981001 | 0.065
943437 | 23.7 | no | yes | 12.5 | 9.9 | 9.9 | 15 | 12 | 12 | 15 | 12 | 15 mmø-12 mmø-12 mmø | REHAU T-piece RAUTITAN LX 20 - 16 - 16 | 4007360459215 | 1976 | https://oxomi.com/p/3000126/datasheet/-/11680341001 | 0.101
943719 | 22.3 | no | yes | 9.9 | 9.9 | 6.6 | 12 | 12 | 10 | 12 | 10 | 12 mmø-10 mmø-12 mmø | REHAU T-piece RAUTITAN LX 16 - 16 - 12 | 4007360468842 | 1973 | https://oxomi.com/p/3000126/datasheet/-/11680291001 | 0.074
943743 | 24.2 | no | yes | 12.5 | 12.5 | 9.9 | 15 | 15 | 12 | 15 | 12 | 15 mmø-12 mmø-15 mmø | REHAU T-piece RAUTITAN LX 20 - 20 - 16 | 4007360459222 | 1977 | https://oxomi.com/p/3000126/datasheet/-/11680361001 | 0.121
944019 | 27.6 | no | yes | 15.2 | 15.2 | 9.9 | 20 | 20 | 12 | 20 | 12 | 20 mmø-12 mmø-20 mmø | REHAU T-piece RAUTITAN LX +G 25 - 25 - 16 | 4007360542955 | 2024 | https://oxomi.com/p/3000126/datasheet/-/13129631001 | 0.19
944027 | 30.2 | no | yes | 20 | 12.5 | 15.2 | 25 | 15 | 20 | 25 | 15 | 25 mmø-20 mmø-15 mmø | REHAU T-piece RAUTITAN LX 32 - 20 - 25 | 4007360459390 | 1989 | https://oxomi.com/p/3000126/datasheet/-/11680531001 | 0.257

# IfcFlowFitting: RAUTITAN_T-piece_LX:RTI LX/PX T DN (23)
In: REHAU Starting view
Type - Material: Br
Type - Other - Category: Pipe Fittings; Sleeve LX: Sleeve : LX 7,4; Family Name: RAUTITAN_T-piece_LX; Max Sleeve: 32 mm; Min Sleeve: 12 mm; Sleeve PX: Sleeve : PX 7,4; T1: RTI T-piece LX; T2: RTI T-piece LX DN1+3
Type - Constraints - Default Elevation: 0 mm
Type - Data - Language: Description en; Language Tender Text: Tender Text en; Region Check: Check DE; Region PID: PID DE; Region URL: Product URL DE; T3: RTI T-piece LX DN2; T4: Sleeve DN
Type - Identity Data - Assembly Code: D2090800; Classification Number: 23.60.30.11.14; Manufacturer: REHAU; Model: RAUTITAN; REHAU Info: 14.02.2024-420668-420668; Type Name: RTI LX/PX T DN
Type - Materials and Finishes - Mat. Fitting: Br
Type - Mechanical - Loss Method: K Coefficient; K Coefficient: 1; K Coefficient Table: Converging/Diverging/Side Tee
Type - Pset_ManufacturerTypeInformation - Manufacturer: REHAU
Classification: D2090800 (Uniformat)
Pset_DistributionFlowElementCommon - Reference: RAUTITAN_T-piece_LX:RTI LX/PX T DN; sets with these values: 2
Other - IsCustom: no; Family: RAUTITAN_T-piece_LX; Family and Type: RAUTITAN_T-piece_LX: RTI LX/PX T DN; Type: RTI LX/PX T DN; Type Id: 782582
Constraints - Elevation from Level: 0 mm; Level: REHAU Starting view
Data - PID Check: 1 mm
Dimensions - Area: 0.00465431 m2
Graphics - Use Annotation Scale: no
Identity Data - Sorting: 0; ETIM Class: EC003025; ETIM Class code: EC003025; ETIM Group: EG015540; ETIM Name: Fitting with 3 connections; Tender text: -
Mechanical - System Classification: Undefined
Phasing - Phase Created: New Construction
Insulation - Insulation Thickness: 0 mm
Name (RAUTITAN_T-piece_LX:RTI LX/PX T DN:...) | V1 | V2 | Sleeve DN1 | Sleeve DN2 | Sleeve DN3 | L4 (mm) | Di1 (mm) | Di2 (mm) | Di3 (mm) | DN1 (mm) | DN2 (mm) | DN3 (mm) | Maximum Size (mm) | Minimum Size (mm) | Size = Overall Size | Volume (m3) | Description long | GTIN | PID | Product Group | Product URL | Weight
1007350 | yes | no | Sleeve : PX 7,4 | Sleeve : PX 7,4 | Sleeve : PX 7,4 | 27.6 | 15.2 | 15.2 | 15.2 | 20 | 20 | 20 | 20 | 20 | 20 mmø-20 mmø-20 mmø | 0.000038145 | REHAU T-piece RAUTITAN LX +G 25 - 25 - 25 | 4007360542832 | 13129511001 | 2013 | https://oxomi.com/p/3000126/datasheet/-/13129511001 | 0.217
1007352 | yes | no | Sleeve : PX 7,4 | Sleeve : PX 7,4 | Sleeve : PX 7,4 | 33 | 20 | 20 | 20 | 25 | 25 | 25 | 25 | 25 | 25 mmø-25 mmø-25 mmø | 0.0000524202 | REHAU T-piece RAUTITAN LX +G 32 - 32 - 32 | 4007360542849 | 13129521001 | 2014 | https://oxomi.com/p/3000126/datasheet/-/13129521001 | 0.39
1007354 | yes | no | Sleeve : PX 7,4 | Sleeve : PX 7,4 | Sleeve : PX 7,4 | 43 | 23 | 23 | 23 | 32 | 32 | 32 | 32 | 32 | 32 mmø-32 mmø-32 mmø | 0.00010493 | REHAU T-piece RAUTITAN LX +G 40 - 40 - 40 | 4007360542856 | 13129531001 | 2015 | https://oxomi.com/p/3000126/datasheet/-/13129531001 | 0.8
1007356 | yes | no | Sleeve : LX 7,4 | Sleeve : LX 7,4 | Sleeve : LX 7,4 | 46 | 30 | 30 | 30 | 40 | 40 | 40 | 40 | 40 | 40 mmø-40 mmø-40 mmø | 0.000154605 | REHAU T-piece RAUTITAN LX 50 - 50 - 50 | 4007360459802 | 11680751001 | 2004 | https://oxomi.com/p/3000126/datasheet/-/11680751001 | 1.19
1007358 | yes | no | Sleeve : LX 7,4 | Sleeve : LX 7,4 | Sleeve : LX 7,4 | 54.5 | 39 | 39 | 39 | 50 | 50 | 50 | 50 | 50 | 50 mmø-50 mmø-50 mmø | 0.000256231 | REHAU T-piece RAUTITAN LX 63 - 63 - 63 | 4007360459864 | 11680811001 | 2006 | https://oxomi.com/p/3000126/datasheet/-/11680811001 | 2.2
1007360 | yes | no | Sleeve : PX 7,4 | Sleeve : PX 7,4 | Sleeve : PX 7,4 | 24.2 | 12.5 | 12.5 | 12.5 | 15 | 15 | 15 | 15 | 15 | 15 mmø-15 mmø-15 mmø | 0.0000202194 | REHAU T-piece RAUTITAN LX +G 20 - 20 - 20 | 4007360542825 | 13129491001 | 2012 | https://oxomi.com/p/3000126/datasheet/-/13129491001 | 0.13
1007364 | yes | no | Sleeve : PX 7,4 | Sleeve : PX 7,4 | Sleeve : PX 7,4 | 27.2 | 15.2 | 12.5 | 15.2 | 20 | 15 | 20 | 20 | 15 | 20 mmø-20 mmø-15 mmø | 0.0000306317 | REHAU T-piece RAUTITAN LX +G 25 - 20 - 25 | 4007360542900 | 13129581001 | 2020 | https://oxomi.com/p/3000126/datasheet/-/13129581001 | 0.19
1007366 | yes | no | Sleeve : PX 7,4 | Sleeve : PX 7,4 | Sleeve : PX 7,4 | 30.6 | 20 | 15.2 | 20 | 25 | 20 | 25 | 25 | 20 | 25 mmø-25 mmø-20 mmø | 0.0000470933 | REHAU T-piece RAUTITAN LX +G 32 - 25 - 32 | 4007360542924 | 13129601001 | 2021 | https://oxomi.com/p/3000126/datasheet/-/13129601001 | 0.34
1007368 | yes | no | Sleeve : PX 7,4 | Sleeve : PX 7,4 | Sleeve : PX 7,4 | 38.5 | 23 | 20 | 23 | 32 | 25 | 32 | 32 | 25 | 32 mmø-32 mmø-25 mmø | 0.0000855319 | REHAU T-piece RAUTITAN LX 40 - 32 - 40 | 4007360459536 | 11680671001 | 1997 | https://oxomi.com/p/3000126/datasheet/-/11680671001 | 0.646
1007370 | yes | no | Sleeve : LX 7,4 | Sleeve : PX 7,4 | Sleeve : LX 7,4 | 46 | 30 | 23 | 30 | 40 | 32 | 40 | 40 | 32 | 40 mmø-40 mmø-32 mmø | 0.000135864 | REHAU T-piece RAUTITAN LX 50 - 40 - 50 | 4007360459796 | 11680741001 | 2003 | https://oxomi.com/p/3000126/datasheet/-/11680741001 | 1.036
1007372 | yes | no | Sleeve : LX 7,4 | Sleeve : LX 7,4 | Sleeve : LX 7,4 | 53 | 39 | 30 | 39 | 50 | 40 | 50 | 50 | 40 | 50 mmø-50 mmø-40 mmø | 0.000219423 | REHAU T-piece RAUTITAN LX 63 - 50 - 63 | 4007360459857 | 11680801001 | 2009 | https://oxomi.com/p/3000126/datasheet/-/11680801001 | 1.645
1007378 | yes | no | Sleeve : PX 7,4 | Sleeve : PX 7,4 | Sleeve : PX 7,4 | 30.2 | 20 | 12.5 | 20 | 25 | 15 | 25 | 25 | 15 | 25 mmø-25 mmø-15 mmø | 0.0000397954 | REHAU T-piece RAUTITAN LX 32 - 20 - 32 | 4007360459406 | 11680541001 | 1990 | https://oxomi.com/p/3000126/datasheet/-/11680541001 | 0.29
1007380 | yes | no | Sleeve : PX 7,4 | Sleeve : PX 7,4 | Sleeve : PX 7,4 | 36.2 | 23 | 15.2 | 23 | 32 | 20 | 32 | 32 | 20 | 32 mmø-32 mmø-20 mmø | 0.0000793327 | REHAU T-piece RAUTITAN LX 40 - 25 - 40 | 4007360459512 | 11680651001 | 1995 | https://oxomi.com/p/3000126/datasheet/-/11680651001 | 0.642
1007382 | yes | no | Sleeve : LX 7,4 | Sleeve : PX 7,4 | Sleeve : LX 7,4 | 42 | 30 | 20 | 30 | 40 | 25 | 40 | 40 | 25 | 40 mmø-40 mmø-25 mmø | 0.000115932 | REHAU T-piece RAUTITAN LX 50 - 32 - 50 | 4007360459789 | 11680731001 | 2002 | https://oxomi.com/p/3000126/datasheet/-/11680731001 | 0.84
1007384 | yes | no | Sleeve : LX 7,4 | Sleeve : PX 7,4 | Sleeve : LX 7,4 | 50 | 39 | 20 | 39 | 50 | 25 | 50 | 50 | 25 | 50 mmø-50 mmø-25 mmø | 0.00017642 | REHAU T-piece RAUTITAN LX 63 - 32 - 63 | 4007360459833 | 11680781001 | 2007 | https://oxomi.com/p/3000126/datasheet/-/11680781001 | 1.45
1007388 | yes | no | Sleeve : LX 7,4 | Sleeve : PX 7,4 | Sleeve : LX 7,4 | 45.2 | 30 | 15.2 | 30 | 40 | 20 | 40 | 40 | 20 | 40 mmø-40 mmø-20 mmø | 0.000109861 | REHAU T-piece RAUTITAN LX 50 - 25 - 50 | 4007360459765 | 11680711001 | 2000 | https://oxomi.com/p/3000126/datasheet/-/11680711001 | 0.805
1007392 | yes | no | Sleeve : PX 7,4 | Sleeve : PX 7,4 | Sleeve : PX 7,4 | 24.7 | 12.5 | 15.2 | 12.5 | 15 | 20 | 15 | 20 | 15 | 20 mmø-15 mmø-15 mmø | 0.0000266215 | REHAU T-piece RAUTITAN LX 20 - 25 - 20 | 4007360459253 | 11680391001 | 1979 | https://oxomi.com/p/3000126/datasheet/-/11680391001 | 0.173
1007396 | no | yes | Sleeve : PX 7,4 | Sleeve : PX 7,4 | Sleeve : PX 7,4 | 27.2 | 15.2 | 12.5 | 12.5 | 20 | 15 | 15 | 20 | 15 | 20 mmø-15 mmø-15 mmø | 0.000026918 | REHAU T-piece RAUTITAN LX +G 25 - 20 - 20 | 4007360542979 | 13129651001 | 2026 | https://oxomi.com/p/3000126/datasheet/-/13129651001 | 0.178
1007398 | no | yes | Sleeve : PX 7,4 | Sleeve : PX 7,4 | Sleeve : PX 7,4 | 30.6 | 20 | 15.2 | 15.2 | 25 | 20 | 20 | 25 | 20 | 25 mmø-20 mmø-20 mmø | 0.0000429953 | REHAU T-piece RAUTITAN LX +G 32 - 25 - 25 | 4007360542986 | 13129661001 | 2027 | https://oxomi.com/p/3000126/datasheet/-/13129661001 | 0.299
1007400 | no | yes | Sleeve : PX 7,4 | Sleeve : PX 7,4 | Sleeve : PX 7,4 | 38.5 | 23 | 20 | 20 | 32 | 25 | 25 | 32 | 25 | 32 mmø-25 mmø-25 mmø | 0.0000723559 | REHAU T-piece RAUTITAN LX 40 - 32 - 40 | 4007360459529 | 11680661001 | 1996 | https://oxomi.com/p/3000126/datasheet/-/11680661001 | 0.526
1007406 | no | yes | Sleeve : PX 7,4 | Sleeve : PX 7,4 | Sleeve : PX 7,4 | 27.2 | 15.2 | 15.2 | 12.5 | 20 | 20 | 15 | 20 | 15 | 20 mmø-15 mmø-20 mmø | 0.0000344125 | REHAU T-piece RAUTITAN LX +G 25 - 25 - 20 | 4007360542962 | 13129641001 | 2025 | https://oxomi.com/p/3000126/datasheet/-/13129641001 | 0.218
1007408 | no | yes | Sleeve : PX 7,4 | Sleeve : PX 7,4 | Sleeve : PX 7,4 | 31.4 | 20 | 20 | 15.2 | 25 | 25 | 20 | 25 | 20 | 25 mmø-20 mmø-25 mmø | 0.0000489107 | REHAU T-piece RAUTITAN LX 32 - 32 - 25 | 4007360459451 | 11680591001 | 1993 | https://oxomi.com/p/3000126/datasheet/-/11680591001 | 0.356
1007412 | no | yes | Sleeve : LX 7,4 | Sleeve : PX 7,4 | Sleeve : PX 7,4 | 42 | 30 | 20 | 23 | 40 | 25 | 32 | 40 | 25 | 40 mmø-32 mmø-25 mmø | 0.000107112 | REHAU T-piece RAUTITAN LX 50 - 32 - 40 | 4007360459772 | 11680721001 | 1998 | https://oxomi.com/p/3000126/datasheet/-/11680721001 | 0.88

# IfcFlowFitting: RAUTITAN_T-piece_LX:RTI LX/PX T DN (13)
In: REHAU Starting view
Type - Material: Br, Error
Type - Other - Category: Pipe Fittings; Sleeve LX: Sleeve : LX 7,4; Family Name: RAUTITAN_T-piece_LX; Max Sleeve: 32 mm; Min Sleeve: 12 mm; Sleeve PX: Sleeve : PX 7,4; T1: RTI T-piece LX; T2: RTI T-piece LX DN1+3
Type - Constraints - Default Elevation: 0 mm
Type - Data - Language: Description en; Language Tender Text: Tender Text en; Region Check: Check DE; Region PID: PID DE; Region URL: Product URL DE; T3: RTI T-piece LX DN2; T4: Sleeve DN
Type - Identity Data - Assembly Code: D2090800; Classification Number: 23.60.30.11.14; Manufacturer: REHAU; Model: RAUTITAN; REHAU Info: 14.02.2024-420668-420668; Type Name: RTI LX/PX T DN
Type - Materials and Finishes - Mat. Fitting: Br
Type - Mechanical - Loss Method: K Coefficient; K Coefficient: 1; K Coefficient Table: Converging/Diverging/Side Tee
Type - Pset_ManufacturerTypeInformation - Manufacturer: REHAU
Classification: D2090800 (Uniformat)
Pset_DistributionFlowElementCommon - Reference: RAUTITAN_T-piece_LX:RTI LX/PX T DN; sets with these values: 2
Other - IsCustom: yes; Family: RAUTITAN_T-piece_LX; Family and Type: RAUTITAN_T-piece_LX: RTI LX/PX T DN; Type: RTI LX/PX T DN; Type Id: 782582
Constraints - Elevation from Level: 0 mm; Level: REHAU Starting view
Data - PID Check: 0 mm
Dimensions - Area: 0.00465431 m2; Volume: 0.0000321717 m3
Graphics - Use Annotation Scale: no
Identity Data - Sorting: 0; ETIM Class: EC003025; ETIM Class code: EC003025; ETIM Group: EG015540; ETIM Name: Fitting with 3 connections; PID: -; Tender text: -
Mechanical - System Classification: Undefined
Phasing - Phase Created: New Construction
Insulation - Insulation Thickness: 0 mm
Name (RAUTITAN_T-piece_LX:RTI LX/PX T DN:...) | Sleeve DN1 | Sleeve DN2 | Sleeve DN3 | V1 | V2 | L4 (mm) | Di1 (mm) | Di2 (mm) | Di3 (mm) | DN1 (mm) | DN2 (mm) | DN3 (mm) | Maximum Size (mm) | Minimum Size (mm) | Size = Overall Size | Description long | GTIN | Product Group | Product URL | Weight
1007346 | Sleeve : LX 7,4 | Sleeve : LX 7,4 | Sleeve : LX 7,4 | yes | no | 20 | 6.6 | 6.6 | 6.6 | 10 | 10 | 10 | 10 | 10 | 10 mmø-10 mmø-10 mmø | REHAU T-piece RAUTITAN LX 12 - 12 - 12 | 4007360557409 | 1970 | https://oxomi.com/p/3000126/datasheet/-/11681971001 | 0.06
1007348 | Sleeve : PX 7,4 | Sleeve : PX 7,4 | Sleeve : PX 7,4 | yes | no | 22.3 | 9.9 | 9.9 | 9.9 | 12 | 12 | 12 | 12 | 12 | 12 mmø-12 mmø-12 mmø | REHAU T-piece RAUTITAN LX +G 16 - 16 - 16 | 4007360542818 | 2011 | https://oxomi.com/p/3000126/datasheet/-/13129481001 | 0.087
1007362 | Sleeve : PX 7,4 | Sleeve : LX 7,4 | Sleeve : PX 7,4 | yes | no | 22 | 9.9 | 6.6 | 9.9 | 12 | 10 | 12 | 12 | 10 | 12 mmø-12 mmø-10 mmø | REHAU T-piece RAUTITAN LX 16 - 12 - 16 | 4007360468835 | 1972 | https://oxomi.com/p/3000126/datasheet/-/11680281001 | 0.07
1007374 | Sleeve : PX 7,4 | Sleeve : PX 7,4 | Sleeve : PX 7,4 | yes | no | 23.7 | 12.5 | 9.9 | 12.5 | 15 | 12 | 15 | 15 | 12 | 15 mmø-15 mmø-12 mmø | REHAU T-piece RAUTITAN LX +G 20 - 16 - 20 | 4007360542887 | 2018 | https://oxomi.com/p/3000126/datasheet/-/13129561001 | 0.11
1007376 | Sleeve : PX 7,4 | Sleeve : PX 7,4 | Sleeve : PX 7,4 | yes | no | 26.7 | 15.2 | 9.9 | 15.2 | 20 | 12 | 20 | 20 | 12 | 20 mmø-20 mmø-12 mmø | REHAU T-piece RAUTITAN LX +G 25 - 16 - 25 | 4007360542894 | 2019 | https://oxomi.com/p/3000126/datasheet/-/13129571001 | 0.16
1007386 | Sleeve : PX 7,4 | Sleeve : LX 7,4 | Sleeve : PX 7,4 | yes | no | 23.4 | 12.5 | 6.6 | 12.5 | 15 | 10 | 15 | 15 | 10 | 15 mmø-15 mmø-10 mmø | REHAU T-piece RAUTITAN LX 20 - 12 - 20 | 4007360468859 | 1975 | https://oxomi.com/p/3000126/datasheet/-/11680331001 | 0.108
1007390 | Sleeve : PX 7,4 | Sleeve : PX 7,4 | Sleeve : PX 7,4 | yes | no | 22.5 | 9.9 | 12.5 | 9.9 | 12 | 15 | 12 | 15 | 12 | 15 mmø-12 mmø-12 mmø | REHAU T-piece RAUTITAN LX 16 - 20 - 16 | 4007360459192 | 1974 | https://oxomi.com/p/3000126/datasheet/-/11680311001 | 0.106
1007394 | Sleeve : PX 7,4 | Sleeve : LX 7,4 | Sleeve : LX 7,4 | no | yes | 22 | 9.9 | 6.6 | 6.6 | 12 | 10 | 10 | 12 | 10 | 12 mmø-10 mmø-10 mmø | REHAU T-piece RAUTITAN LX 16 - 12 - 12 | 4007360557416 | 1971 | https://oxomi.com/p/3000126/datasheet/-/11681981001 | 0.065
1007402 | Sleeve : PX 7,4 | Sleeve : PX 7,4 | Sleeve : PX 7,4 | no | yes | 23.7 | 12.5 | 9.9 | 9.9 | 15 | 12 | 12 | 15 | 12 | 15 mmø-12 mmø-12 mmø | REHAU T-piece RAUTITAN LX 20 - 16 - 16 | 4007360459215 | 1976 | https://oxomi.com/p/3000126/datasheet/-/11680341001 | 0.101
1007404 | Sleeve : PX 7,4 | Sleeve : PX 7,4 | Sleeve : LX 7,4 | no | yes | 22.3 | 9.9 | 9.9 | 6.6 | 12 | 12 | 10 | 12 | 10 | 12 mmø-10 mmø-12 mmø | REHAU T-piece RAUTITAN LX 16 - 16 - 12 | 4007360468842 | 1973 | https://oxomi.com/p/3000126/datasheet/-/11680291001 | 0.074
1007410 | Sleeve : PX 7,4 | Sleeve : PX 7,4 | Sleeve : PX 7,4 | no | yes | 24.2 | 12.5 | 12.5 | 9.9 | 15 | 15 | 12 | 15 | 12 | 15 mmø-12 mmø-15 mmø | REHAU T-piece RAUTITAN LX 20 - 20 - 16 | 4007360459222 | 1977 | https://oxomi.com/p/3000126/datasheet/-/11680361001 | 0.121
1007414 | Sleeve : PX 7,4 | Sleeve : PX 7,4 | Sleeve : PX 7,4 | no | yes | 27.6 | 15.2 | 15.2 | 9.9 | 20 | 20 | 12 | 20 | 12 | 20 mmø-12 mmø-20 mmø | REHAU T-piece RAUTITAN LX +G 25 - 25 - 16 | 4007360542955 | 2024 | https://oxomi.com/p/3000126/datasheet/-/13129631001 | 0.19
1007416 | Sleeve : PX 7,4 | Sleeve : PX 7,4 | Sleeve : PX 7,4 | no | yes | 30.2 | 20 | 12.5 | 15.2 | 25 | 15 | 20 | 25 | 15 | 25 mmø-20 mmø-15 mmø | REHAU T-piece RAUTITAN LX 32 - 20 - 25 | 4007360459390 | 1989 | https://oxomi.com/p/3000126/datasheet/-/11680531001 | 0.257

# IfcFlowFitting: RAUTITAN_T-piece_PX:RTI PX T DN (34)
In: REHAU Starting view
Type - Material: PX
Type - Other - Category: Pipe Fittings; Family Name: RAUTITAN_T-piece_PX; T1: RTI T-piece PX; T2: RTI T-piece PX DN1+3
Type - Constraints - Default Elevation: 0 mm
Type - Data - Language: Description en; Language Tender Text: Tender Text en; Region Check: Check DE; Region PID: PID DE; Region URL: Product URL DE; T3: RTI T-piece PX DN2; T4: Sleeve DN
Type - Identity Data - Assembly Code: D2090800; Classification Number: 23.60.30.11.14; Manufacturer: REHAU; Model: RAUTITAN; REHAU Info: 14.02.2024-420668-420668; Type Name: RTI PX T DN
Type - Materials and Finishes - Mat. Fitting: PX
Type - Mechanical - Loss Method: K Coefficient; K Coefficient: 1; K Coefficient Table: Converging/Diverging/Side Tee
Type - Pset_ManufacturerTypeInformation - Manufacturer: REHAU
Classification: D2090800 (Uniformat)
Pset_DistributionFlowElementCommon - Reference: RAUTITAN_T-piece_PX:RTI PX T DN; sets with these values: 2
Other - IsCustom: no; Family: RAUTITAN_T-piece_PX; Family and Type: RAUTITAN_T-piece_PX: RTI PX T DN; Type: RTI PX T DN; Type Id: 786163
Constraints - Elevation from Level: 0 mm; Level: REHAU Starting view
Data - PID Check: 1 mm
Dimensions - Area: 0.00465431 m2
Graphics - Use Annotation Scale: no
Identity Data - Sorting: 0; ETIM Class: EC003025; ETIM Group: EG015540; ETIM Name: Fitting with 3 connections; Tender text: -
Mechanical - System Classification: Undefined
Phasing - Phase Created: New Construction
Insulation - Insulation Thickness: 0 mm
Name (RAUTITAN_T-piece_PX:RTI PX T DN:...) | V1 | V2 | L4 (mm) | Di1 (mm) | Di2 (mm) | Di3 (mm) | DN1 (mm) | DN2 (mm) | DN3 (mm) | Do1 (mm) | Maximum Size (mm) | Minimum Size (mm) | Size = Overall Size | Volume (m3) | Description long | GTIN | PID | Product Group | Product URL | Weight
1078163 | yes | no | 23 | 9 | 9 | 9 | 12 | 12 | 12 | 11.5 | 12 | 12 | 12 mmø-12 mmø-12 mmø | 0.0000119285 | REHAU T-piece RAUTITAN PX 16 - 16 - 16 | 4007360366506 | 11600311001 | 2029 | https://oxomi.com/p/3000126/datasheet/-/11600311001 | 0.0155
1078165 | yes | no | 28.8 | 13.5 | 13.5 | 13.5 | 20 | 20 | 20 | 17 | 20 | 20 | 20 mmø-20 mmø-20 mmø | 0.0000326461 | REHAU T-piece RAUTITAN PX 25 - 25 - 25 | 4007360366520 | 11600331001 | 2031 | https://oxomi.com/p/3000126/datasheet/-/11600331001 | 0.0426
1078167 | yes | no | 33 | 18.1 | 18.1 | 18.1 | 25 | 25 | 25 | 22.1 | 25 | 25 | 25 mmø-25 mmø-25 mmø | 0.0000589276 | REHAU T-piece RAUTITAN PX 32 - 32 - 32 | 4007360366537 | 11600341001 | 2032 | https://oxomi.com/p/3000126/datasheet/-/11600341001 | 0.0759
1078169 | yes | no | 42 | 22 | 22 | 22 | 32 | 32 | 32 | 28 | 32 | 32 | 32 mmø-32 mmø-32 mmø | 0.000118183 | REHAU T-piece RAUTITAN PX 40 - 40 - 40 | 4007360366544 | 11600351001 | 2033 | https://oxomi.com/p/3000126/datasheet/-/11600351001 | 0.1416
1078171 | yes | no | 25.6 | 11.2 | 11.2 | 11.2 | 15 | 15 | 15 | 14.6 | 15 | 15 | 15 mmø-15 mmø-15 mmø | 0.0000204742 | REHAU T-piece RAUTITAN PX 20 - 20 - 20 | 4007360366513 | 11600321001 | 2030 | https://oxomi.com/p/3000126/datasheet/-/11600321001 | 0.02515
1078186 | yes | no | 28.6 | 13.5 | 11.2 | 13.5 | 20 | 15 | 20 | 17 | 20 | 15 | 20 mmø-20 mmø-15 mmø | 0.0000280137 | REHAU T-piece RAUTITAN PX 25 - 20 - 25 | 4007360375836 | 11600631001 | 2036 | https://oxomi.com/p/3000126/datasheet/-/11600631001 | 0.0359
1078188 | yes | no | 32.3 | 18.1 | 13.5 | 18.1 | 25 | 20 | 25 | 22.1 | 25 | 20 | 25 mmø-25 mmø-20 mmø | 0.00004887 | REHAU T-piece RAUTITAN PX 32 - 25 - 32 | 4007360375867 | 11600661001 | 2039 | https://oxomi.com/p/3000126/datasheet/-/11600661001 | 0.062
1078190 | yes | no | 40.5 | 22 | 18.1 | 22 | 32 | 25 | 32 | 28 | 32 | 25 | 32 mmø-32 mmø-25 mmø | 0.0000959464 | REHAU T-piece RAUTITAN PX 40 - 32 - 40 | 4007360376970 | 11600691001 | 2042 | https://oxomi.com/p/3000126/datasheet/-/11600691001 | 0.1151
1078192 | yes | no | 25 | 11.2 | 9 | 11.2 | 15 | 12 | 15 | 14.6 | 15 | 12 | 15 mmø-15 mmø-12 mmø | 0.0000170815 | REHAU T-piece RAUTITAN PX 20 - 16 - 20 | 4007360375812 | 11600611001 | 2034 | https://oxomi.com/p/3000126/datasheet/-/11600611001 | 0.0216
1078199 | yes | no | 28 | 13.5 | 9 | 13.5 | 20 | 12 | 20 | 17 | 20 | 12 | 20 mmø-20 mmø-12 mmø | 0.0000244402 | REHAU T-piece RAUTITAN PX 25 - 16 - 25 | 4007360375829 | 11600621001 | 2035 | https://oxomi.com/p/3000126/datasheet/-/11600621001 | 0.0316
1078201 | yes | no | 32.1 | 18.1 | 11.2 | 18.1 | 25 | 15 | 25 | 22.1 | 25 | 15 | 25 mmø-25 mmø-15 mmø | 0.0000438463 | REHAU T-piece RAUTITAN PX 32 - 20 - 32 | 4007360375850 | 11600651001 | 2038 | https://oxomi.com/p/3000126/datasheet/-/11600651001 | 0.0557
1078203 | yes | no | 39.8 | 22 | 13.5 | 22 | 32 | 20 | 32 | 28 | 32 | 20 | 32 mmø-32 mmø-20 mmø | 0.0000842172 | REHAU T-piece RAUTITAN PX 40 - 25 - 40 | 4007360376963 | 11600681001 | 2041 | https://oxomi.com/p/3000126/datasheet/-/11600681001 | 0.1014
1078210 | yes | no | 31.5 | 18.1 | 9 | 18.1 | 25 | 12 | 25 | 22.1 | 25 | 12 | 25 mmø-25 mmø-12 mmø | 0.0000399308 | REHAU T-piece RAUTITAN PX 32 - 16 - 32 | 4007360375843 | 11600641001 | 2037 | https://oxomi.com/p/3000126/datasheet/-/11600641001 | 0.0514
1078212 | yes | no | 39.6 | 22 | 11.2 | 22 | 32 | 15 | 32 | 28 | 32 | 15 | 32 mmø-32 mmø-15 mmø | 0.0000779347 | REHAU T-piece RAUTITAN PX 40 - 20 - 40 | 4007360376956 | 11600671001 | 2040 | https://oxomi.com/p/3000126/datasheet/-/11600671001 | 0.0932
1078218 | yes | no | 23.6 | 9 | 11.2 | 9 | 12 | 15 | 12 | 11.5 | 15 | 12 | 15 mmø-12 mmø-12 mmø | 0.0000153575 | REHAU T-piece RAUTITAN PX 16 - 20 - 16 | 4007360375911 | 11601011001 | 2058 | https://oxomi.com/p/3000126/datasheet/-/11601011001 | 0.0191
1078220 | yes | no | 29.5 | 13.5 | 18.1 | 13.5 | 20 | 25 | 20 | 17 | 25 | 20 | 25 mmø-20 mmø-20 mmø | 0.0000419278 | REHAU T-piece RAUTITAN PX 25 - 32 - 25 | 4007360377113 | 11601061001 | 2062 | https://oxomi.com/p/3000126/datasheet/-/11601061001 | 0.0544
1078222 | yes | no | 25.8 | 11.2 | 13.5 | 11.2 | 15 | 20 | 15 | 14.6 | 20 | 15 | 20 mmø-15 mmø-15 mmø | 0.000024866 | REHAU T-piece RAUTITAN PX 20 - 25 - 20 | 4007360375928 | 11601041001 | 2061 | https://oxomi.com/p/3000126/datasheet/-/11601041001 | 0.0311
1078227 | yes | no | 23.8 | 9 | 13.5 | 9 | 12 | 20 | 12 | 11.5 | 20 | 12 | 20 mmø-12 mmø-12 mmø | 0.0000190362 | REHAU T-piece RAUTITAN PX 16 - 25 - 16 | 4007360377090 | 11601021001 | 2059 | https://oxomi.com/p/3000126/datasheet/-/11601021001 | 0.0248
1078229 | no | yes | 25 | 11.2 | 9 | 9 | 15 | 12 | 12 | 14.6 | 15 | 12 | 15 mmø-12 mmø-12 mmø | 0.0000149739 | REHAU T-piece RAUTITAN PX 20 - 16 - 16 | 4007360375881 | 11600811001 | 2048 | https://oxomi.com/p/3000126/datasheet/-/11600811001 | 0.0192
1078231 | no | yes | 28.6 | 13.5 | 11.2 | 11.2 | 20 | 15 | 15 | 17 | 20 | 15 | 20 mmø-15 mmø-15 mmø | 0.0000245341 | REHAU T-piece RAUTITAN PX 25 - 20 - 20 | 4007360375904 | 11600851001 | 2052 | https://oxomi.com/p/3000126/datasheet/-/11600851001 | 0.0311
1078233 | no | yes | 32.3 | 18.1 | 13.5 | 13.5 | 25 | 20 | 20 | 22.1 | 25 | 20 | 25 mmø-20 mmø-20 mmø | 0.0000422073 | REHAU T-piece RAUTITAN PX 32 - 25 - 25 | 4007360377076 | 11600911001 | 2056 | https://oxomi.com/p/3000126/datasheet/-/11600911001 | 0.0534
1078235 | no | yes | 40.5 | 22 | 18.1 | 18.1 | 32 | 25 | 25 | 28 | 32 | 25 | 32 mmø-25 mmø-25 mmø | 0.0000819779 | REHAU T-piece RAUTITAN PX 40 - 32 - 32 | 4007360377083 | 11600921001 | 2057 | https://oxomi.com/p/3000126/datasheet/-/11600921001 | 0.0986
1078238 | no | yes | 28 | 13.5 | 9 | 9 | 20 | 12 | 12 | 17 | 20 | 12 | 20 mmø-12 mmø-12 mmø | 0.0000190681 | REHAU T-piece RAUTITAN PX 25 - 16 - 16 | 4007360377021 | 11600821001 | 2049 | https://oxomi.com/p/3000126/datasheet/-/11600821001 | 0.0251
1078240 | no | yes | 32.1 | 18.1 | 11.2 | 11.2 | 25 | 15 | 15 | 22.1 | 25 | 15 | 25 mmø-15 mmø-15 mmø | 0.0000337098 | REHAU T-piece RAUTITAN PX 32 - 20 - 20 | 4007360377045 | 11600861001 | 2053 | https://oxomi.com/p/3000126/datasheet/-/11600861001 | 0.0428
1078243 | no | yes | 25.6 | 11.2 | 11.2 | 9 | 15 | 15 | 12 | 14.6 | 15 | 12 | 15 mmø-12 mmø-15 mmø | 0.0000182895 | REHAU T-piece RAUTITAN PX 20 - 20 - 16 | 4007360375874 | 11600711001 | 2043 | https://oxomi.com/p/3000126/datasheet/-/11600711001 | 0.0226
1078245 | no | yes | 28.8 | 13.5 | 13.5 | 11.2 | 20 | 20 | 15 | 17 | 20 | 15 | 20 mmø-15 mmø-20 mmø | 0.0000291664 | REHAU T-piece RAUTITAN PX 25 - 25 - 20 | 4007360376994 | 11600731001 | 2045 | https://oxomi.com/p/3000126/datasheet/-/11600731001 | 0.0377
1078247 | no | yes | 33 | 18.1 | 18.1 | 13.5 | 25 | 25 | 20 | 22.1 | 25 | 20 | 25 mmø-20 mmø-25 mmø | 0.000052152 | REHAU T-piece RAUTITAN PX 32 - 32 - 25 | 4007360377014 | 11600751001 | 2047 | https://oxomi.com/p/3000126/datasheet/-/11600751001 | 0.0658
1078250 | no | yes | 28.8 | 13.5 | 13.5 | 9 | 20 | 20 | 12 | 17 | 20 | 12 | 20 mmø-12 mmø-20 mmø | 0.0000271815 | REHAU T-piece RAUTITAN PX 25 - 25 - 16 | 4007360376987 | 11600721001 | 2044 | https://oxomi.com/p/3000126/datasheet/-/11600721001 | 0.0353
1078252 | no | yes | 33 | 18.1 | 18.1 | 11.2 | 25 | 25 | 15 | 22.1 | 25 | 15 | 25 mmø-15 mmø-25 mmø | 0.000048104 | REHAU T-piece RAUTITAN PX 32 - 32 - 20 | 4007360377007 | 11600741001 | 2046 | https://oxomi.com/p/3000126/datasheet/-/11600741001 | 0.06124
1078255 | no | yes | 25.8 | 11.2 | 13.5 | 9 | 15 | 20 | 12 | 14.6 | 20 | 12 | 20 mmø-15 mmø-12 mmø | 0.0000226813 | REHAU T-piece RAUTITAN PX 20 - 25 - 16 | 4007360377106 | 11601031001 | 2060 | https://oxomi.com/p/3000126/datasheet/-/11601031001 | 0.0286
1078257 | no | yes | 28 | 13.5 | 9 | 11.2 | 20 | 12 | 15 | 17 | 20 | 12 | 20 mmø-15 mmø-12 mmø | 0.0000209947 | REHAU T-piece RAUTITAN PX 25 - 16 - 20 | 4007360375898 | 11600831001 | 2050 | https://oxomi.com/p/3000126/datasheet/-/11600831001 | 0.0276
1078259 | no | yes | 32.1 | 18.1 | 11.2 | 13.5 | 25 | 15 | 20 | 22.1 | 25 | 15 | 25 mmø-20 mmø-15 mmø | 0.0000371836 | REHAU T-piece RAUTITAN PX 32 - 20 - 25 | 4007360377052 | 11600871001 | 2054 | https://oxomi.com/p/3000126/datasheet/-/11600871001 | 0.0471
1078262 | no | yes | 28.6 | 13.5 | 11.2 | 9 | 20 | 15 | 12 | 17 | 20 | 12 | 20 mmø-12 mmø-15 mmø | 0.0000225492 | REHAU T-piece RAUTITAN PX 25 - 20 - 16 | 4007360377038 | 11600841001 | 2051 | https://oxomi.com/p/3000126/datasheet/-/11600841001 | 0.0287
1078264 | no | yes | 32.3 | 18.1 | 13.5 | 11.2 | 25 | 20 | 15 | 22.1 | 25 | 15 | 25 mmø-15 mmø-20 mmø | 0.0000387335 | REHAU T-piece RAUTITAN PX 32 - 25 - 20 | 4007360377069 | 11600891001 | 2055 | https://oxomi.com/p/3000126/datasheet/-/11600891001 | 0.0497

# IfcFlowFitting: RAUTITAN_T-piece_RX+ stabil:RTI RX+ stabil T DN (10)
In: REHAU Starting view
Type - Material: RX
Type - Other - Category: Pipe Fittings; Family Name: RAUTITAN_T-piece_RX+ stabil; T1: RTI T-piece RX+ stabil; T2: RTI T-piece RX+ stabil DN1+3
Type - Constraints - Default Elevation: 0 mm
Type - Data - Language: Description en; Language Tender Text: Tender Text en; Region Check: Check DE; Region PID: PID DE; Region URL: Product URL DE; T4: Sleeve DN
Type - Identity Data - Assembly Code: D2090800; Manufacturer: REHAU; Model: RAUTITAN; REHAU Info: 14.02.2024-420668-420668; Type Name: RTI RX+ stabil T DN
Type - Materials and Finishes - Mat. Error: Error; Mat. Fitting: RX
Type - Mechanical - K Coefficient: 1; K Coefficient Table: Converging/Diverging/Side Tee; Loss Method: K Coefficient from Table
Type - Pset_ManufacturerTypeInformation - Manufacturer: REHAU
Classification: D2090800 (Uniformat)
Pset_DistributionFlowElementCommon - Reference: RAUTITAN_T-piece_RX+ stabil:RTI RX+ stabil T DN; sets with these values: 2
Other - IsCustom: no; Family: RAUTITAN_T-piece_RX+ stabil; Family and Type: RAUTITAN_T-piece_RX+ stabil: RTI RX+ stabil T DN; Type: RTI RX+ stabil T DN; Type Id: 327176
Constraints - Elevation from Level: 0 mm; Level: REHAU Starting view
Data - PID Check: 1 mm
Dimensions - Area: 0.00465431 m2
Graphics - Use Annotation Scale: no
Identity Data - Sorting: 0; ETIM Class: EC003025; ETIM Group: EG015540; ETIM Name: Fitting with 3 connections; Tender text: -
Mechanical - System Classification: Undefined
Phasing - Phase Created: New Construction
Insulation - Insulation Thickness: 0 mm
Name (RAUTITAN_T-piece_RX+ stabil:RTI RX+ stabil T DN:...) | V1 | V2 | L4 (mm) | Di1 (mm) = Di3 (mm) | Di2 (mm) | DN1 (mm) = Maximum Size (mm) | DN2 (mm) = Minimum Size (mm) | DN3 (mm) | Size = Overall Size | Volume (m3) | Description long | GTIN | PID | Product Group | Product URL | Weight
1078181 | yes | no | 49 | 33.5 | 33.5 | 40 | 40 | 40 | 40 mmø-40 mmø-40 mmø | 0.000179541 | REHAU T-piece RAUTITAN RX+ stabil 50 - 50 - 50 | 4062178676001 | 14600131001 | 2148 | https://oxomi.com/p/3000126/datasheet/-/14600131001 | 1.22
1078183 | yes | no | 60 | 45.5 | 45.5 | 50 | 50 | 50 | 50 mmø-50 mmø-50 mmø | 0.000258458 | REHAU T-piece RAUTITAN RX+ stabil 63 - 63 - 63 | 4062178676018 | 14600141001 | 2149 | https://oxomi.com/p/3000126/datasheet/-/14600141001 | 2.034
1078194 | yes | no | 54 | 33.5 | 23.5 | 40 | 32 | 40 | 40 mmø-40 mmø-32 mmø | 0.000168376 | REHAU T-piece RAUTITAN RX+ stabil 50 - 40 - 50 | 4062178755478 | 14600211001 | 2154 | https://oxomi.com/p/3000126/datasheet/-/14600211001 | 1.086
1078196 | yes | no | 57 | 45.5 | 33.5 | 50 | 40 | 50 | 50 mmø-50 mmø-40 mmø | 0.000226902 | REHAU T-piece RAUTITAN RX+ stabil 63 - 50 - 63 | 4062178676025 | 14600221001 | 2155 | https://oxomi.com/p/3000126/datasheet/-/14600221001 | 1.728
1078205 | yes | no | 53 | 33.5 | 20 | 40 | 25 | 40 | 40 mmø-40 mmø-25 mmø | 0.000139608 | REHAU T-piece RAUTITAN RX+ stabil 50 - 32 - 50 | 4062178755447 | 14600171001 | 2151 | https://oxomi.com/p/3000126/datasheet/-/14600171001 | 0.924
1078207 | yes | no | 63 | 45.5 | 23.5 | 50 | 32 | 50 | 50 mmø-50 mmø-32 mmø | 0.000214302 | REHAU T-piece RAUTITAN RX+ stabil 63 - 40 - 63 | 4062178755485 | 14600231001 | 2156 | https://oxomi.com/p/3000126/datasheet/-/14600231001 | 1.573
1078214 | yes | no | 49 | 33.5 | 15.2 | 40 | 20 | 40 | 40 mmø-40 mmø-20 mmø | 0.000124161 | REHAU T-piece RAUTITAN RX+ stabil 50 - 25 - 50 | 4062178755430 | 14600161001 | 2150 | https://oxomi.com/p/3000126/datasheet/-/14600161001 | 0.844
1078216 | yes | no | 60 | 45.5 | 20 | 50 | 25 | 50 | 50 mmø-50 mmø-25 mmø | 0.000185402 | REHAU T-piece RAUTITAN RX+ stabil 63 - 32 - 63 | 4062178755461 | 14600191001 | 2153 | https://oxomi.com/p/3000126/datasheet/-/14600191001 | 1.406
1078225 | yes | no | 53 | 45.5 | 15.2 | 50 | 20 | 50 | 50 mmø-50 mmø-20 mmø | 0.000171352 | REHAU T-piece RAUTITAN RX+ stabil 63 - 25 - 63 | 4062178755454 | 14600181001 | 2152 | https://oxomi.com/p/3000126/datasheet/-/14600181001 | 1.326
1078266 | no | yes | 49 | 33.5 | 16 | 40 | 20 | 32 | 40 mmø-32 mmø-20 mmø | 0.00011229 | REHAU T-piece RAUTITAN RX+ stabil 50 - 25 - 40 | 4064299603539 | 14600281001 | 2157 | https://oxomi.com/p/3000126/datasheet/-/14600281001 | 728

# IfcFlowFitting: RAUTITAN_T-piece_RX+:RTI RX+ T DN (19)
In: REHAU Starting view
