Properties of the parts of a building model (IFC2X3), part 5 of 9

# IfcFlowFitting: RAUTITAN_WM_Corner_RP_RX+:16 - RP1/2 Short (2)
Identity Data - Description long: REHAU Wall-mounted elbow RAUTITAN RX+ 16 - Rp 1/2 short; GTIN: 4061264397721; PID: 14563581001; Weight: 127
Phasing - Phase Created: New Construction
Insulation - Insulation Thickness: 0 mm
Name (RAUTITAN_WM_Corner_RP_RX+:16 - RP1/2 Short:...) | Ins. Box
1086951 | no
1354062 | yes

# IfcFlowFitting: RAUTITAN_WM_Corner_RP_RX+:20 - RP1/2 Long (2)
In: REHAU Starting view
Type - Material: RAUTITAN RX+
Type - Other - Category: Pipe Fittings; Backplate: RTI_Backplate : 01; Frontplate: RTI_Frontplate : 05; V Backplate: yes; V Frontplate: no; Family Name: RAUTITAN_WM_Corner_RP_RX+; L1: 21 mm; L1+Z2: 24.8 mm; L4: 36.8 mm; L5: 52 mm; r1: 13 mm; r2: 10.2 mm; T1: RTI WM Corner RP RX P1; T2: RTI WM Corner RP RX; Z2: 3.8 mm; Z4: 20.1 mm
Type - Constraints - Default Elevation: 0 mm
Type - Data - Language: Description EN; Plate: 01; Region Check: Check DE; Region PID: PID DE; Type: Long
Type - Dimensions - Di1: 12.5 mm; Di2: 20.4 mm; DN1: 15 mm; DN2: 15 mm; Do2: 26 mm
Type - Identity Data - Classification Number: 23.60.30.11.14; Manufacturer: REHAU; Model: RAUTITAN; Type Name: 20 - RP1/2 Long
Type - Pset_ManufacturerTypeInformation - Manufacturer: REHAU
Pset_DistributionFlowElementCommon - Reference: RAUTITAN_WM_Corner_RP_RX+:20 - RP1/2 Long; sets with these values: 2
Other - IsCustom: no; Family: RAUTITAN_WM_Corner_RP_RX+; Family and Type: RAUTITAN_WM_Corner_RP_RX+: 20 - RP1/2 Long; Type: 20 - RP1/2 Long; Type Id: 1340798
Constraints - Elevation from Level: 0 mm; Level: REHAU Starting view; Moves With Nearby Elements: no
Data - PID Check: 1 mm
Dimensions - Angle test: 45 deg; Area: 0.0147273 m2; Volume: 0.0000231015 m3
Identity Data - Description long: REHAU Wall-mounted elbow RAUTITAN RX+ 20 - Rp 1/2 long; GTIN: 4061264397776; PID: 14563631001; Weight: 143
Phasing - Phase Created: New Construction
Insulation - Insulation Thickness: 0 mm
Name (RAUTITAN_WM_Corner_RP_RX+:20 - RP1/2 Long:...) | Ins. Box
1086955 | no
1354066 | yes

# IfcFlowFitting: RAUTITAN_WM_Corner_RP_RX+:20 - RP1/2 Short (2)
In: REHAU Starting view
Type - Material: RAUTITAN RX+
Type - Other - Category: Pipe Fittings; Backplate: RTI_Backplate : 01; Frontplate: RTI_Frontplate : 05; V Backplate: yes; V Frontplate: no; Family Name: RAUTITAN_WM_Corner_RP_RX+; L1: 21 mm; L1+Z2: 24.8 mm; L4: 24.8 mm; L5: 40 mm; r1: 13 mm; r2: 10.2 mm; T1: RTI WM Corner RP RX P1; T2: RTI WM Corner RP RX; Z2: 3.8 mm; Z4: 20.1 mm
Type - Constraints - Default Elevation: 0 mm
Type - Data - Language: Description EN; Plate: 01; Region Check: Check DE; Region PID: PID DE; Type: Short
Type - Dimensions - Di1: 12.5 mm; Di2: 20.4 mm; DN1: 15 mm; DN2: 15 mm; Do2: 26 mm
Type - Identity Data - Classification Number: 23.60.30.11.14; Manufacturer: REHAU; Model: RAUTITAN; Type Name: 20 - RP1/2 Short
Type - Pset_ManufacturerTypeInformation - Manufacturer: REHAU
Pset_DistributionFlowElementCommon - Reference: RAUTITAN_WM_Corner_RP_RX+:20 - RP1/2 Short; sets with these values: 2
Other - IsCustom: no; Family: RAUTITAN_WM_Corner_RP_RX+; Family and Type: RAUTITAN_WM_Corner_RP_RX+: 20 - RP1/2 Short; Type: 20 - RP1/2 Short; Type Id: 1340790
Constraints - Elevation from Level: 0 mm; Level: REHAU Starting view; Moves With Nearby Elements: no
Data - PID Check: 1 mm
Dimensions - Angle test: 45 deg; Area: 0.0138526 m2; Volume: 0.0000206423 m3
Identity Data - Description long: REHAU Wall-mounted elbow RAUTITAN RX+ 20 - Rp 1/2 short; GTIN: 4061264397738; PID: 14563591001; Weight: 121
Phasing - Phase Created: New Construction
Insulation - Insulation Thickness: 0 mm
Name (RAUTITAN_WM_Corner_RP_RX+:20 - RP1/2 Short:...) | Ins. Box
1086959 | no
1354070 | yes

# IfcFlowFitting: RAUTITAN_WM_Corner_RP_RX+:20 - RP3/4 Short, RAUTITAN_WM_Corner_RP_RX+:20 - RP3/4 Short:1086963
In: REHAU Starting view
Type - Material: RAUTITAN RX+
Type - Other - Category: Pipe Fittings; Backplate: RTI_Backplate : 01; Frontplate: RTI_Frontplate : 05; V Backplate: yes; V Frontplate: no; Family Name: RAUTITAN_WM_Corner_RP_RX+; L1: 24 mm; L1+Z2: 27.8 mm; L4: 24.8 mm; L5: 40 mm; r1: 16.25 mm; r2: 13.45 mm; T1: RTI WM Corner RP RX P1; T2: RTI WM Corner RP RX; Z2: 3.8 mm; Z4: 20.1 mm
Type - Constraints - Default Elevation: 0 mm
Type - Data - Language: Description EN; Plate: 01; Region Check: Check DE; Region PID: PID DE; Type: Short
Type - Dimensions - Di1: 12.5 mm; Di2: 26.9 mm; DN1: 15 mm; DN2: 20 mm; Do2: 32.5 mm
Type - Identity Data - Classification Number: 23.60.30.11.14; Manufacturer: REHAU; Model: RAUTITAN; Type Name: 20 - RP3/4 Short
Type - Pset_ManufacturerTypeInformation - Manufacturer: REHAU
Pset_DistributionFlowElementCommon - Reference: RAUTITAN_WM_Corner_RP_RX+:20 - RP3/4 Short; sets with these values: 2
Other - IsCustom: no; Family: RAUTITAN_WM_Corner_RP_RX+; Ins. Box: no; Family and Type: RAUTITAN_WM_Corner_RP_RX+: 20 - RP3/4 Short; Type: 20 - RP3/4 Short; Type Id: 1340792
Constraints - Elevation from Level: 0 mm; Level: REHAU Starting view; Moves With Nearby Elements: no
Data - PID Check: 1 mm
Dimensions - Angle test: 45 deg; Area: 0.0145612 m2; Volume: 0.0000225641 m3
Identity Data - Description long: REHAU Wall-mounted elbow RAUTITAN RX+ 20 - Rp 3/4 short; GTIN: 4061264397745; PID: 14563601001; Weight: 149
Phasing - Phase Created: New Construction
Insulation - Insulation Thickness: 0 mm

# IfcFlowFitting: RAUTITAN_WM_Corner_RP_RX+:25 - RP3/4 Short, RAUTITAN_WM_Corner_RP_RX+:25 - RP3/4 Short:1086967
In: REHAU Starting view
Type - Material: RAUTITAN RX+
Type - Other - Category: Pipe Fittings; Backplate: RTI_Backplate : 01; Frontplate: RTI_Frontplate : 05; V Backplate: yes; V Frontplate: no; Family Name: RAUTITAN_WM_Corner_RP_RX+; L1: 23.3 mm; L1+Z2: 28.2 mm; L4: 28.1 mm; L5: 45 mm; r1: 16.25 mm; r2: 13.45 mm; T1: RTI WM Corner RP RX P1; T2: RTI WM Corner RP RX; Z2: 4.9 mm; Z4: 25 mm
Type - Constraints - Default Elevation: 0 mm
Type - Data - Language: Description EN; Plate: 01; Region Check: Check DE; Region PID: PID DE; Type: Short
Type - Dimensions - Di1: 15.2 mm; Di2: 26.9 mm; DN1: 20 mm; DN2: 20 mm; Do2: 32.5 mm
Type - Identity Data - Classification Number: 23.60.30.11.14; Manufacturer: REHAU; Model: RAUTITAN; Type Name: 25 - RP3/4 Short
Type - Pset_ManufacturerTypeInformation - Manufacturer: REHAU
Pset_DistributionFlowElementCommon - Reference: RAUTITAN_WM_Corner_RP_RX+:25 - RP3/4 Short; sets with these values: 2
Other - IsCustom: no; Family: RAUTITAN_WM_Corner_RP_RX+; Ins. Box: no; Family and Type: RAUTITAN_WM_Corner_RP_RX+: 25 - RP3/4 Short; Type: 25 - RP3/4 Short; Type Id: 1340794
Constraints - Elevation from Level: 0 mm; Level: REHAU Starting view; Moves With Nearby Elements: no
Data - PID Check: 1 mm
Dimensions - Angle test: 45 deg; Area: 0.0161525 m2; Volume: 0.0000279633 m3
Identity Data - Description long: REHAU Wall-mounted elbow RAUTITAN RX+ 25 - Rp 3/4 short; GTIN: 4061264397752; PID: 14563611001; Weight: 181
Phasing - Phase Created: New Construction
Insulation - Insulation Thickness: 0 mm

# IfcFlowFitting: RAUTITAN_WM_Corner_RP_RX+:Assembly unit 55 16 - RP1/2, RAUTITAN_WM_Corner_RP_RX+:Assembly unit 55 16 - RP1/2:1086971
In: REHAU Starting view
Type - Material: RAUTITAN RX+
Type - Other - Category: Pipe Fittings; Frontplate: RTI_Frontplate : 05; Backplate: RTI_Backplate : 03; Family Name: RAUTITAN_WM_Corner_RP_RX+; L1: 22.2 mm; L1+Z2: 25.8 mm; L4: 69.2 mm; L5: 86.2 mm; r1: 13 mm; r2: 10.2 mm; T1: RTI WM Corner RP RX P1; T2: RTI WM Corner RP RX; V Backplate: no; V Frontplate: yes; Z2: 3.6 mm; Z4: 17.1 mm
Type - Constraints - Default Elevation: 0 mm
Type - Data - Language: Description EN; Plate: 05; Region Check: Check DE; Region PID: PID DE; Type: Assembly unit 55
Type - Dimensions - Di1: 9.9 mm; Di2: 20.4 mm; DN1: 12 mm; DN2: 15 mm; Do2: 26 mm
Type - Identity Data - Classification Number: 23.60.30.11.14; Manufacturer: REHAU; Model: RAUTITAN; Type Name: Assembly unit 55 16 - RP1/2
Type - Pset_ManufacturerTypeInformation - Manufacturer: REHAU
Pset_DistributionFlowElementCommon - Reference: RAUTITAN_WM_Corner_RP_RX+:Assembly unit 55 16 - RP1/2; sets with these values: 2
Other - IsCustom: no; Family: RAUTITAN_WM_Corner_RP_RX+; Ins. Box: no; Family and Type: RAUTITAN_WM_Corner_RP_RX+: Assembly unit 55 16 - RP1/2; Type: Assembly unit 55 16 - RP1/2; Type Id: 1340824
Constraints - Elevation from Level: 0 mm; Level: REHAU Starting view; Moves With Nearby Elements: no
Data - PID Check: 1 mm
Dimensions - Angle test: 45 deg; Area: 0.01651 m2; Volume: 0.0000307052 m3
Identity Data - Description long: REHAU Wall-mounted elbow RAUTITAN RX+ 16 - Rp 1/2 x 55 for assembly unit; GTIN: 4061264397936; PID: 14563791001; Weight: 244
Phasing - Phase Created: New Construction
Insulation - Insulation Thickness: 0 mm

# IfcFlowFitting: RAUTITAN_WM_Corner_RP_RX+:Chipboard 28 16 - RP1/2, RAUTITAN_WM_Corner_RP_RX+:Chipboard 28 16 - RP1/2:1086975
In: REHAU Starting view
Type - Material: RAUTITAN RX+
Type - Other - Category: Pipe Fittings; Backplate: RTI_Backplate : 03; V Backplate: no; V Frontplate: yes; Family Name: RAUTITAN_WM_Corner_RP_RX+; Frontplate: RTI_Frontplate : 04; L1: 22.2 mm; L1+Z2: 25.8 mm; L4: 42.2 mm; L5: 59.2 mm; r1: 13 mm; r2: 10.2 mm; T1: RTI WM Corner RP RX P1; T2: RTI WM Corner RP RX; Z2: 3.6 mm; Z4: 17.1 mm
Type - Constraints - Default Elevation: 0 mm
Type - Data - Language: Description EN; Plate: 04; Region Check: Check DE; Region PID: PID DE; Type: Chipboard 28
Type - Dimensions - Di1: 9.9 mm; Di2: 20.4 mm; DN1: 12 mm; DN2: 15 mm; Do2: 26 mm
Type - Identity Data - Classification Number: 23.60.30.11.14; Manufacturer: REHAU; Model: RAUTITAN; Type Name: Chipboard 28 16 - RP1/2
Type - Pset_ManufacturerTypeInformation - Manufacturer: REHAU
Pset_DistributionFlowElementCommon - Reference: RAUTITAN_WM_Corner_RP_RX+:Chipboard 28 16 - RP1/2; sets with these values: 2
Other - IsCustom: no; Family: RAUTITAN_WM_Corner_RP_RX+; Ins. Box: no; Family and Type: RAUTITAN_WM_Corner_RP_RX+: Chipboard 28 16 - RP1/2; Type: Chipboard 28 16 - RP1/2; Type Id: 1340816
Constraints - Elevation from Level: 0 mm; Level: REHAU Starting view; Moves With Nearby Elements: no
Data - PID Check: 1 mm
Dimensions - Angle test: 45 deg; Area: 0.0145421 m2; Volume: 0.0000263641 m3
Identity Data - Description long: REHAU Wall-mounted elbow RAUTITAN RX+ 16 - Rp 1/2 x 28 for chipboard; GTIN: 4061264397905; PID: 14563761001; Weight: 245
Phasing - Phase Created: New Construction
Insulation - Insulation Thickness: 0 mm

# IfcFlowFitting: RAUTITAN_WM_Corner_RP_RX+:Chipboard 28 20 - RP1/2, RAUTITAN_WM_Corner_RP_RX+:Chipboard 28 20 - RP1/2:1086979
In: REHAU Starting view
Type - Material: RAUTITAN RX+
Type - Other - Category: Pipe Fittings; Backplate: RTI_Backplate : 03; V Backplate: no; V Frontplate: yes; Frontplate: RTI_Frontplate : 04; Family Name: RAUTITAN_WM_Corner_RP_RX+; L1: 21 mm; L1+Z2: 24.8 mm; L4: 44.3 mm; L5: 61.3 mm; r1: 13 mm; r2: 10.2 mm; T1: RTI WM Corner RP RX P1; T2: RTI WM Corner RP RX; Z2: 3.8 mm; Z4: 20.1 mm
Type - Constraints - Default Elevation: 0 mm
Type - Data - Language: Description EN; Plate: 04; Region Check: Check DE; Region PID: PID DE; Type: Chipboard 28
Type - Dimensions - Di1: 12.5 mm; Di2: 20.4 mm; DN1: 15 mm; DN2: 15 mm; Do2: 26 mm
Type - Identity Data - Classification Number: 23.60.30.11.14; Manufacturer: REHAU; Model: RAUTITAN; Type Name: Chipboard 28 20 - RP1/2
Type - Pset_ManufacturerTypeInformation - Manufacturer: REHAU
Pset_DistributionFlowElementCommon - Reference: RAUTITAN_WM_Corner_RP_RX+:Chipboard 28 20 - RP1/2; sets with these values: 2
Other - IsCustom: no; Family: RAUTITAN_WM_Corner_RP_RX+; Ins. Box: no; Family and Type: RAUTITAN_WM_Corner_RP_RX+: Chipboard 28 20 - RP1/2; Type: Chipboard 28 20 - RP1/2; Type Id: 1340820
Constraints - Elevation from Level: 0 mm; Level: REHAU Starting view; Moves With Nearby Elements: no
Data - PID Check: 1 mm
Dimensions - Angle test: 45 deg; Area: 0.0153155 m2; Volume: 0.0000285383 m3
Identity Data - Description long: REHAU Wall-mounted elbow RAUTITAN RX+ 20 - Rp 1/2 x 28 for chipboard; GTIN: 4061264397912; PID: 14563771001; Weight: 212
Phasing - Phase Created: New Construction
Insulation - Insulation Thickness: 0 mm

# IfcFlowFitting: RAUTITAN_WM_Corner_RP_RX+:Chipboard 35 16 - RP1/2, RAUTITAN_WM_Corner_RP_RX+:Chipboard 35 16 - RP1/2:1086983
In: REHAU Starting view
Type - Material: RAUTITAN RX+
Type - Other - Category: Pipe Fittings; Frontplate: RTI_Frontplate : 05; Backplate: RTI_Backplate : 03; V Backplate: no; V Frontplate: yes; Family Name: RAUTITAN_WM_Corner_RP_RX+; L1: 22.2 mm; L1+Z2: 25.8 mm; L4: 49.2 mm; L5: 66.2 mm; r1: 13 mm; r2: 10.2 mm; T1: RTI WM Corner RP RX P1; T2: RTI WM Corner RP RX; Z2: 3.6 mm; Z4: 17.1 mm
Type - Constraints - Default Elevation: 0 mm
Type - Data - Language: Description EN; Plate: 05; Region Check: Check DE; Region PID: PID DE; Type: Chipboard 35
Type - Dimensions - Di1: 9.9 mm; Di2: 20.4 mm; DN1: 12 mm; DN2: 15 mm; Do2: 26 mm
Type - Identity Data - Classification Number: 23.60.30.11.14; Manufacturer: REHAU; Model: RAUTITAN; Type Name: Chipboard 35 16 - RP1/2
Type - Pset_ManufacturerTypeInformation - Manufacturer: REHAU
Pset_DistributionFlowElementCommon - Reference: RAUTITAN_WM_Corner_RP_RX+:Chipboard 35 16 - RP1/2; sets with these values: 2
Other - IsCustom: no; Family: RAUTITAN_WM_Corner_RP_RX+; Ins. Box: no; Family and Type: RAUTITAN_WM_Corner_RP_RX+: Chipboard 35 16 - RP1/2; Type: Chipboard 35 16 - RP1/2; Type Id: 1340818
Constraints - Elevation from Level: 0 mm; Level: REHAU Starting view; Moves With Nearby Elements: no
Data - PID Check: 1 mm
Dimensions - Angle test: 45 deg; Area: 0.0150523 m2; Volume: 0.0000266064 m3
Identity Data - Description long: REHAU Wall-mounted elbow RAUTITAN RX+ 16 - Rp 1/2 x 35 for chipboard; GTIN: 4061264398339; PID: 14564191001; Weight: 228
Phasing - Phase Created: New Construction
Insulation - Insulation Thickness: 0 mm

# IfcFlowFitting: RAUTITAN_WM_Corner_RP_RX+:Chipboard 55 16 - RP1/2, RAUTITAN_WM_Corner_RP_RX+:Chipboard 55 16 - RP1/2:1086987
In: REHAU Starting view
Type - Material: RAUTITAN RX+
Type - Other - Category: Pipe Fittings; Frontplate: RTI_Frontplate : 05; Backplate: RTI_Backplate : 03; V Backplate: no; V Frontplate: yes; Family Name: RAUTITAN_WM_Corner_RP_RX+; L1: 22.2 mm; L1+Z2: 25.8 mm; L4: 69.2 mm; L5: 86.2 mm; r1: 13 mm; r2: 10.2 mm; T1: RTI WM Corner RP RX P1; T2: RTI WM Corner RP RX; Z2: 3.6 mm; Z4: 17.1 mm
Type - Constraints - Default Elevation: 0 mm
Type - Data - Language: Description EN; Plate: 05; Region Check: Check DE; Region PID: PID DE; Type: Chipboard 55
Type - Dimensions - Di1: 9.9 mm; Di2: 20.4 mm; DN1: 12 mm; DN2: 15 mm; Do2: 26 mm
Type - Identity Data - Classification Number: 23.60.30.11.14; Manufacturer: REHAU; Model: RAUTITAN; Type Name: Chipboard 55 16 - RP1/2
Type - Pset_ManufacturerTypeInformation - Manufacturer: REHAU
Pset_DistributionFlowElementCommon - Reference: RAUTITAN_WM_Corner_RP_RX+:Chipboard 55 16 - RP1/2; sets with these values: 2
Other - IsCustom: no; Family: RAUTITAN_WM_Corner_RP_RX+; Ins. Box: no; Family and Type: RAUTITAN_WM_Corner_RP_RX+: Chipboard 55 16 - RP1/2; Type: Chipboard 55 16 - RP1/2; Type Id: 1340822
Constraints - Elevation from Level: 0 mm; Level: REHAU Starting view; Moves With Nearby Elements: no
Data - PID Check: 1 mm
Dimensions - Angle test: 45 deg; Area: 0.01651 m2; Volume: 0.0000307052 m3
Identity Data - Description long: REHAU Wall-mounted elbow RAUTITAN RX+ 16 - Rp 1/2 x 55 for chipboard; GTIN: 4061264397929; PID: 14563781001; Weight: 244
Phasing - Phase Created: New Construction
Insulation - Insulation Thickness: 0 mm

# IfcFlowFitting: RAUTITAN_WM_Corner_RP_RX+:Plasterboard 16 - RP1/2, RAUTITAN_WM_Corner_RP_RX+:Plasterboard 16 - RP1/2:1086991
In: REHAU Starting view
Type - Material: RAUTITAN RX+
Type - Other - Category: Pipe Fittings; Backplate: RTI_Backplate : 03; V Backplate: no; V Frontplate: yes; Frontplate: RTI_Frontplate : 04; Family Name: RAUTITAN_WM_Corner_RP_RX+; L1: 22.2 mm; L1+Z2: 25.8 mm; L4: 42.2 mm; L5: 59.2 mm; r1: 13 mm; r2: 10.2 mm; T1: RTI WM Corner RP RX P1; T2: RTI WM Corner RP RX; Z2: 3.6 mm; Z4: 17.1 mm
Type - Constraints - Default Elevation: 0 mm
Type - Data - Language: Description EN; Plate: 04; Region Check: Check DE; Region PID: PID DE; Type: Plasterboard
Type - Dimensions - Di1: 9.9 mm; Di2: 20.4 mm; DN1: 12 mm; DN2: 15 mm; Do2: 26 mm
Type - Identity Data - Classification Number: 23.60.30.11.14; Manufacturer: REHAU; Model: RAUTITAN; Type Name: Plasterboard 16 - RP1/2
Type - Pset_ManufacturerTypeInformation - Manufacturer: REHAU
Pset_DistributionFlowElementCommon - Reference: RAUTITAN_WM_Corner_RP_RX+:Plasterboard 16 - RP1/2; sets with these values: 2
Other - IsCustom: no; Family: RAUTITAN_WM_Corner_RP_RX+; Ins. Box: no; Family and Type: RAUTITAN_WM_Corner_RP_RX+: Plasterboard 16 - RP1/2; Type: Plasterboard 16 - RP1/2; Type Id: 1340812
Constraints - Elevation from Level: 0 mm; Level: REHAU Starting view; Moves With Nearby Elements: no
Data - PID Check: 1 mm
Dimensions - Angle test: 45 deg; Area: 0.0145421 m2; Volume: 0.0000263641 m3
Identity Data - Description long: REHAU Wall-mounted elbow RAUTITAN RX+ 16 - Rp 1/2 for plasterboard; GTIN: 4061264397882; PID: 14563741001; Weight: 202
Phasing - Phase Created: New Construction
Insulation - Insulation Thickness: 0 mm

# IfcFlowFitting: RAUTITAN_WM_Corner_RP_RX+:Plasterboard 20 - RP1/2, RAUTITAN_WM_Corner_RP_RX+:Plasterboard 20 - RP1/2:1086995
In: REHAU Starting view
Type - Material: RAUTITAN RX+
Type - Other - Category: Pipe Fittings; Backplate: RTI_Backplate : 03; V Backplate: no; V Frontplate: yes; Frontplate: RTI_Frontplate : 04; Family Name: RAUTITAN_WM_Corner_RP_RX+; L1: 21 mm; L1+Z2: 24.8 mm; L4: 44.3 mm; L5: 61.3 mm; r1: 13 mm; r2: 10.2 mm; T1: RTI WM Corner RP RX P1; T2: RTI WM Corner RP RX; Z2: 3.8 mm; Z4: 20.1 mm
Type - Constraints - Default Elevation: 0 mm
Type - Data - Language: Description EN; Plate: 04; Region Check: Check DE; Region PID: PID DE; Type: Plasterboard
Type - Dimensions - Di1: 12.5 mm; Di2: 20.4 mm; DN1: 15 mm; DN2: 15 mm; Do2: 26 mm
Type - Identity Data - Classification Number: 23.60.30.11.14; Manufacturer: REHAU; Model: RAUTITAN; Type Name: Plasterboard 20 - RP1/2
Type - Pset_ManufacturerTypeInformation - Manufacturer: REHAU
Pset_DistributionFlowElementCommon - Reference: RAUTITAN_WM_Corner_RP_RX+:Plasterboard 20 - RP1/2; sets with these values: 2
Other - IsCustom: no; Family: RAUTITAN_WM_Corner_RP_RX+; Ins. Box: no; Family and Type: RAUTITAN_WM_Corner_RP_RX+: Plasterboard 20 - RP1/2; Type: Plasterboard 20 - RP1/2; Type Id: 1340814
Constraints - Elevation from Level: 0 mm; Level: REHAU Starting view; Moves With Nearby Elements: no
Data - PID Check: 1 mm
Dimensions - Angle test: 45 deg; Area: 0.0153155 m2; Volume: 0.0000285383 m3
Identity Data - Description long: REHAU Wall-mounted elbow RAUTITAN RX+ 20 - Rp 1/2 for plasterboard; GTIN: 4061264397899; PID: 14563751001; Weight: 215
Phasing - Phase Created: New Construction
Insulation - Insulation Thickness: 0 mm

# IfcFlowFitting: RAUTITAN_WM_Corner_RP_RX+:Pre-wall 59 16 - RP1/2, RAUTITAN_WM_Corner_RP_RX+:Pre-wall 59 16 - RP1/2:1086999
In: REHAU Starting view
Type - Material: RAUTITAN RX+
Type - Other - Category: Pipe Fittings; Frontplate: RTI_Frontplate : 05; V Backplate: yes; V Frontplate: no; Backplate: RTI_Backplate : 03; Family Name: RAUTITAN_WM_Corner_RP_RX+; L1: 22.2 mm; L1+Z2: 25.8 mm; L4: 42.8 mm; L5: 57 mm; r1: 13 mm; r2: 10.2 mm; T1: RTI WM Corner RP RX P1; T2: RTI WM Corner RP RX; Z2: 3.6 mm; Z4: 17.1 mm
Type - Constraints - Default Elevation: 0 mm
Type - Data - Language: Description EN; Plate: 03; Region Check: Check DE; Region PID: PID DE; Type: Pre-wall 59
Type - Dimensions - Di1: 9.9 mm; Di2: 20.4 mm; DN1: 12 mm; DN2: 15 mm; Do2: 26 mm
Type - Identity Data - Classification Number: 23.60.30.11.14; Manufacturer: REHAU; Model: RAUTITAN; Type Name: Pre-wall 59 16 - RP1/2
Type - Pset_ManufacturerTypeInformation - Manufacturer: REHAU
Pset_DistributionFlowElementCommon - Reference: RAUTITAN_WM_Corner_RP_RX+:Pre-wall 59 16 - RP1/2; sets with these values: 2
Other - IsCustom: no; Family: RAUTITAN_WM_Corner_RP_RX+; Ins. Box: no; Family and Type: RAUTITAN_WM_Corner_RP_RX+: Pre-wall 59 16 - RP1/2; Type: Pre-wall 59 16 - RP1/2; Type Id: 1340804
Constraints - Elevation from Level: 0 mm; Level: REHAU Starting view; Moves With Nearby Elements: no
Data - PID Check: 1 mm
Dimensions - Angle test: 45 deg; Area: 0.0145211 m2; Volume: 0.000025669 m3
Identity Data - Description long: REHAU Wall-mounted elbow RAUTITAN RX+ 16 - Rp 1/2-59 f. pre-wall installation; GTIN: 4061264397851; PID: 14563711001; Weight: 175
Phasing - Phase Created: New Construction
Insulation - Insulation Thickness: 0 mm

# IfcFlowFitting: RAUTITAN_WM_Corner_RP_RX+:Pre-wall 59 20 - RP1/2, RAUTITAN_WM_Corner_RP_RX+:Pre-wall 59 20 - RP1/2:1087003
In: REHAU Starting view
Type - Material: RAUTITAN RX+
Type - Other - Category: Pipe Fittings; Frontplate: RTI_Frontplate : 05; V Backplate: yes; V Frontplate: no; Backplate: RTI_Backplate : 03; Family Name: RAUTITAN_WM_Corner_RP_RX+; L1: 21 mm; L1+Z2: 24.8 mm; L4: 40.8 mm; L5: 57 mm; r1: 13 mm; r2: 10.2 mm; T1: RTI WM Corner RP RX P1; T2: RTI WM Corner RP RX; Z2: 3.8 mm; Z4: 20.1 mm
Type - Constraints - Default Elevation: 0 mm
Type - Data - Language: Description EN; Plate: 03; Region Check: Check DE; Region PID: PID DE; Type: Pre-wall 59
Type - Dimensions - Di1: 12.5 mm; Di2: 20.4 mm; DN1: 15 mm; DN2: 15 mm; Do2: 26 mm
Type - Identity Data - Classification Number: 23.60.30.11.14; Manufacturer: REHAU; Model: RAUTITAN; Type Name: Pre-wall 59 20 - RP1/2
Type - Pset_ManufacturerTypeInformation - Manufacturer: REHAU
Pset_DistributionFlowElementCommon - Reference: RAUTITAN_WM_Corner_RP_RX+:Pre-wall 59 20 - RP1/2; sets with these values: 2
Other - IsCustom: no; Family: RAUTITAN_WM_Corner_RP_RX+; Ins. Box: no; Family and Type: RAUTITAN_WM_Corner_RP_RX+: Pre-wall 59 20 - RP1/2; Type: Pre-wall 59 20 - RP1/2; Type Id: 1340806
Constraints - Elevation from Level: 0 mm; Level: REHAU Starting view; Moves With Nearby Elements: no
Data - PID Check: 1 mm
Dimensions - Angle test: 45 deg; Area: 0.0150419 m2; Volume: 0.0000270746 m3
Identity Data - Description long: REHAU Wall-mounted elbow RAUTITAN RX+ 20 - Rp 1/2-59 f. pre-wall installation; GTIN: 4061264397868; PID: 14563721001; Weight: 186
Phasing - Phase Created: New Construction
Insulation - Insulation Thickness: 0 mm

# IfcFlowFitting: RAUTITAN_WM_Corner_RP_RX+:Pre-wall 70 16 - RP1/2, RAUTITAN_WM_Corner_RP_RX+:Pre-wall 70 16 - RP1/2:1087007
In: REHAU Starting view
Type - Material: RAUTITAN RX+
Type - Other - Category: Pipe Fittings; Frontplate: RTI_Frontplate : 05; V Backplate: yes; V Frontplate: no; Backplate: RTI_Backplate : 03; Family Name: RAUTITAN_WM_Corner_RP_RX+; L1: 22.2 mm; L1+Z2: 25.8 mm; L4: 55.8 mm; L5: 70 mm; r1: 13 mm; r2: 10.2 mm; T1: RTI WM Corner RP RX P1; T2: RTI WM Corner RP RX; Z2: 3.6 mm; Z4: 17.1 mm
Type - Constraints - Default Elevation: 0 mm
Type - Data - Language: Description EN; Plate: 03; Region Check: Check DE; Region PID: PID DE; Type: Pre-wall 70
Type - Dimensions - Di1: 9.9 mm; Di2: 20.4 mm; DN1: 12 mm; DN2: 15 mm; Do2: 26 mm
Type - Identity Data - Classification Number: 23.60.30.11.14; Manufacturer: REHAU; Model: RAUTITAN; Type Name: Pre-wall 70 16 - RP1/2
Type - Pset_ManufacturerTypeInformation - Manufacturer: REHAU
Pset_DistributionFlowElementCommon - Reference: RAUTITAN_WM_Corner_RP_RX+:Pre-wall 70 16 - RP1/2; sets with these values: 2
Other - IsCustom: no; Family: RAUTITAN_WM_Corner_RP_RX+; Ins. Box: no; Family and Type: RAUTITAN_WM_Corner_RP_RX+: Pre-wall 70 16 - RP1/2; Type: Pre-wall 70 16 - RP1/2; Type Id: 1340808
Constraints - Elevation from Level: 0 mm; Level: REHAU Starting view; Moves With Nearby Elements: no
Data - PID Check: 1 mm
Dimensions - Angle test: 45 deg; Area: 0.0154686 m2; Volume: 0.0000283332 m3
Identity Data - Description long: REHAU Wall-mounted elbow RAUTITAN RX+ 16 - Rp 1/2 - 70; GTIN: 4061264398322; PID: 14564181001; Weight: 195
Phasing - Phase Created: New Construction
Insulation - Insulation Thickness: 0 mm

# IfcFlowFitting: RAUTITAN_WM_Corner_RP_RX+:Pre-wall 70 20 - RP1/2, RAUTITAN_WM_Corner_RP_RX+:Pre-wall 70 20 - RP1/2:1087011
In: REHAU Starting view
Type - Material: RAUTITAN RX+
Type - Other - Category: Pipe Fittings; Frontplate: RTI_Frontplate : 05; V Backplate: yes; V Frontplate: no; Backplate: RTI_Backplate : 03; Family Name: RAUTITAN_WM_Corner_RP_RX+; L1: 21 mm; L1+Z2: 24.8 mm; L4: 53.8 mm; L5: 70 mm; r1: 13 mm; r2: 10.2 mm; T1: RTI WM Corner RP RX P1; T2: RTI WM Corner RP RX; Z2: 3.8 mm; Z4: 20.1 mm
Type - Constraints - Default Elevation: 0 mm
Type - Data - Language: Description EN; Plate: 03; Region Check: Check DE; Region PID: PID DE; Type: Pre-wall 70
Type - Dimensions - Di1: 12.5 mm; Di2: 20.4 mm; DN1: 15 mm; DN2: 15 mm; Do2: 26 mm
Type - Identity Data - Classification Number: 23.60.30.11.14; Manufacturer: REHAU; Model: RAUTITAN; Type Name: Pre-wall 70 20 - RP1/2
Type - Pset_ManufacturerTypeInformation - Manufacturer: REHAU
Pset_DistributionFlowElementCommon - Reference: RAUTITAN_WM_Corner_RP_RX+:Pre-wall 70 20 - RP1/2; sets with these values: 2
Other - IsCustom: no; Family: RAUTITAN_WM_Corner_RP_RX+; Ins. Box: no; Family and Type: RAUTITAN_WM_Corner_RP_RX+: Pre-wall 70 20 - RP1/2; Type: Pre-wall 70 20 - RP1/2; Type Id: 1340810
Constraints - Elevation from Level: 0 mm; Level: REHAU Starting view; Moves With Nearby Elements: no
Data - PID Check: 1 mm
Dimensions - Angle test: 45 deg; Area: 0.0159894 m2; Volume: 0.0000297387 m3
Identity Data - Description long: REHAU Wall-mounted elbow RAUTITAN RX+ 20 - Rp 1/2 - 70; GTIN: 4061264398346; PID: 14564201001; Weight: 212
Phasing - Phase Created: New Construction
Insulation - Insulation Thickness: 0 mm

# IfcFlowFitting: RAUTITAN_WM_Corner_RP_RX+:Squared backplate 16 - RP1/2, RAUTITAN_WM_Corner_RP_RX+:Squared backplate 16 - RP1/2:1087015
In: REHAU Starting view
Type - Material: RAUTITAN RX+
Type - Other - Category: Pipe Fittings; Frontplate: RTI_Frontplate : 05; V Backplate: yes; V Frontplate: no; Backplate: RTI_Backplate : 02; Family Name: RAUTITAN_WM_Corner_RP_RX+; L1: 22.2 mm; L1+Z2: 25.8 mm; L4: 25.8 mm; L5: 40 mm; r1: 13 mm; r2: 10.2 mm; T1: RTI WM Corner RP RX P1; T2: RTI WM Corner RP RX; Z2: 3.6 mm; Z4: 17.1 mm
Type - Constraints - Default Elevation: 0 mm
Type - Data - Language: Description EN; Plate: 02; Region Check: Check DE; Region PID: PID DE; Type: Squared backplate
Type - Dimensions - Di1: 9.9 mm; Di2: 20.4 mm; DN1: 12 mm; DN2: 15 mm; Do2: 26 mm
Type - Identity Data - Classification Number: 23.60.30.11.14; Manufacturer: REHAU; Model: RAUTITAN; Type Name: Squared backplate 16 - RP1/2
Type - Pset_ManufacturerTypeInformation - Manufacturer: REHAU
Pset_DistributionFlowElementCommon - Reference: RAUTITAN_WM_Corner_RP_RX+:Squared backplate 16 - RP1/2; sets with these values: 2
Other - IsCustom: no; Family: RAUTITAN_WM_Corner_RP_RX+; Ins. Box: no; Family and Type: RAUTITAN_WM_Corner_RP_RX+: Squared backplate 16 - RP1/2; Type: Squared backplate 16 - RP1/2; Type Id: 1340800
Constraints - Elevation from Level: 0 mm; Level: REHAU Starting view; Moves With Nearby Elements: no
Data - PID Check: 1 mm
Dimensions - Angle test: 45 deg; Area: 0.013282 m2; Volume: 0.0000213369 m3
Identity Data - Description long: REHAU Wall-mounted elbow RAUTITAN RX+ with square backplate 16 - Rp 1/2; GTIN: 4061264397813; PID: 14563671001; Weight: 143
Phasing - Phase Created: New Construction
Insulation - Insulation Thickness: 0 mm

# IfcFlowFitting: RAUTITAN_WM_Corner_RP_RX+:Squared backplate 20 - RP1/2, RAUTITAN_WM_Corner_RP_RX+:Squared backplate 20 - RP1/2:1087019
In: REHAU Starting view
Type - Material: RAUTITAN RX+
Type - Other - Category: Pipe Fittings; Frontplate: RTI_Frontplate : 05; V Backplate: yes; V Frontplate: no; Backplate: RTI_Backplate : 02; Family Name: RAUTITAN_WM_Corner_RP_RX+; L1: 21 mm; L1+Z2: 24.8 mm; L4: 24.2 mm; L5: 40.5 mm; r1: 13 mm; r2: 10.2 mm; T1: RTI WM Corner RP RX P1; T2: RTI WM Corner RP RX; Z2: 3.8 mm; Z4: 20.1 mm
Type - Constraints - Default Elevation: 0 mm
Type - Data - Language: Description EN; Plate: 02; Region Check: Check DE; Region PID: PID DE; Type: Squared backplate
Type - Dimensions - Di1: 12.5 mm; Di2: 20.4 mm; DN1: 15 mm; DN2: 15 mm; Do2: 26 mm
Type - Identity Data - Classification Number: 23.60.30.11.14; Manufacturer: REHAU; Model: RAUTITAN; Type Name: Squared backplate 20 - RP1/2
Type - Pset_ManufacturerTypeInformation - Manufacturer: REHAU
Pset_DistributionFlowElementCommon - Reference: RAUTITAN_WM_Corner_RP_RX+:Squared backplate 20 - RP1/2; sets with these values: 2
Other - IsCustom: no; Family: RAUTITAN_WM_Corner_RP_RX+; Ins. Box: no; Family and Type: RAUTITAN_WM_Corner_RP_RX+: Squared backplate 20 - RP1/2; Type: Squared backplate 20 - RP1/2; Type Id: 1340802
Constraints - Elevation from Level: 0 mm; Level: REHAU Starting view; Moves With Nearby Elements: no
Data - PID Check: 1 mm
Dimensions - Angle test: 45 deg; Area: 0.0138344 m2; Volume: 0.0000228388 m3
Identity Data - Description long: REHAU Wall-mounted elbow RAUTITAN RX+ with square backplate 20 - Rp 1/2; GTIN: 4061264397837; PID: 14563691001; Weight: 171
Phasing - Phase Created: New Construction
Insulation - Insulation Thickness: 0 mm

# IfcFlowFitting: RAUTITAN_WM_Double_RP_RX+:12-12 Rp 1/2 Long, RAUTITAN_WM_Double_RP_RX+:12-12 Rp 1/2 Long:1087039
In: REHAU Starting view
Type - Material: RAUTITAN RX+
Type - Other - Category: Pipe Fittings; Family Name: RAUTITAN_WM_Double_RP_RX+; T1: RTI WM Double RP RX P1; T2: RTI WM Double RP RX
Type - Constraints - Default Elevation: 0 mm
Type - Data - Language: Description EN; Region Check: Check DE; Region PID: PID DE; Type: Long
Type - Dimensions - Di1: 9.9 mm; Di2: 9.9 mm; Di3: 20.4 mm; Di4: 10.5 mm; DN1: 12 mm; DN2: 12 mm; DN3: 15 mm; Do3: 26 mm; L4: 43.8 mm; L5: 56 mm; r1: 13 mm; r2: 10.2 mm; r3: 25 mm; Z4: 9 mm; Z5: 17.1 mm
Type - Identity Data - Classification Number: 23.60.30.11.14; Manufacturer: REHAU; Model: RAUTITAN; Type Name: 12-12 Rp 1/2 Long
Type - Pset_ManufacturerTypeInformation - Manufacturer: REHAU
Pset_DistributionFlowElementCommon - Reference: RAUTITAN_WM_Double_RP_RX+:12-12 Rp 1/2 Long; sets with these values: 2
Other - IsCustom: no; Family: RAUTITAN_WM_Double_RP_RX+; Family and Type: RAUTITAN_WM_Double_RP_RX+: 12-12 Rp 1/2 Long; Type: 12-12 Rp 1/2 Long; Type Id: 1089437
Constraints - Elevation from Level: 0 mm; Level: REHAU Starting view; Moves With Nearby Elements: no
Data - PID Check: 1 mm
Dimensions - Area: 0.0146925 m2; Volume: 0.000033311 m3
Identity Data - Description long: REHAU Double wall-mounted elbow RAU. RX+ 16/16 - Rp 1/2 long; GTIN: 4061264388484; PID: 14562701001; Weight: 171
Phasing - Phase Created: New Construction
Insulation - Insulation Thickness: 0 mm

# IfcFlowFitting: RAUTITAN_WM_Double_RP_RX+:12-12 Rp 1/2 Short, RAUTITAN_WM_Double_RP_RX+:12-12 Rp 1/2 Short:1087045
In: REHAU Starting view
Type - Material: RAUTITAN RX+
Type - Other - Category: Pipe Fittings; Family Name: RAUTITAN_WM_Double_RP_RX+; T1: RTI WM Double RP RX P1; T2: RTI WM Double RP RX
Type - Constraints - Default Elevation: 0 mm
Type - Data - Language: Description EN; Region Check: Check DE; Region PID: PID DE; Type: Short
Type - Dimensions - Di1: 9.9 mm; Di2: 9.9 mm; Di3: 20.4 mm; Di4: 10.5 mm; DN1: 12 mm; DN2: 12 mm; DN3: 15 mm; Do3: 26 mm; L4: 26.8 mm; L5: 39 mm; r1: 13 mm; r2: 10.2 mm; r3: 25 mm; Z4: 9 mm; Z5: 17.1 mm
Type - Identity Data - Classification Number: 23.60.30.11.14; Manufacturer: REHAU; Model: RAUTITAN; Type Name: 12-12 Rp 1/2 Short
Type - Pset_ManufacturerTypeInformation - Manufacturer: REHAU
Pset_DistributionFlowElementCommon - Reference: RAUTITAN_WM_Double_RP_RX+:12-12 Rp 1/2 Short; sets with these values: 2
Other - IsCustom: no; Family: RAUTITAN_WM_Double_RP_RX+; Family and Type: RAUTITAN_WM_Double_RP_RX+: 12-12 Rp 1/2 Short; Type: 12-12 Rp 1/2 Short; Type Id: 1089435
Constraints - Elevation from Level: 0 mm; Level: REHAU Starting view; Moves With Nearby Elements: no
Data - PID Check: 1 mm
Dimensions - Area: 0.0134534 m2; Volume: 0.0000298268 m3
Identity Data - Description long: REHAU Double wall-mounted elbow RAU. RX+ 16/16 - Rp 1/2 short; GTIN: 4061264398179; PID: 14564031001; Weight: 171
Phasing - Phase Created: New Construction
Insulation - Insulation Thickness: 0 mm

# IfcFlowFitting: RAUTITAN_WM_Double_RP_RX+:12-15 Rp 1/2 Short, RAUTITAN_WM_Double_RP_RX+:12-15 Rp 1/2 Short:1087075
In: REHAU Starting view
Type - Material: RAUTITAN RX+
Type - Other - Category: Pipe Fittings; Family Name: RAUTITAN_WM_Double_RP_RX+; T1: RTI WM Double RP RX P1; T2: RTI WM Double RP RX
Type - Constraints - Default Elevation: 0 mm
Type - Data - Language: Description EN; Region Check: Check DE; Region PID: PID DE; Type: Short
Type - Dimensions - Di1: 9.9 mm; Di2: 12.5 mm; Di3: 20.4 mm; Di4: 13.1 mm; DN1: 12 mm; DN2: 15 mm; DN3: 15 mm; Do3: 26 mm; L4: 24.8 mm; L5: 39 mm; r1: 13 mm; r2: 10.2 mm; r3: 25 mm; Z4: 9 mm; Z5: 17.1 mm
Type - Identity Data - Classification Number: 23.60.30.11.14; Manufacturer: REHAU; Model: RAUTITAN; Type Name: 12-15 Rp 1/2 Short
Type - Pset_ManufacturerTypeInformation - Manufacturer: REHAU
Pset_DistributionFlowElementCommon - Reference: RAUTITAN_WM_Double_RP_RX+:12-15 Rp 1/2 Short; sets with these values: 2
Other - IsCustom: no; Family: RAUTITAN_WM_Double_RP_RX+; Family and Type: RAUTITAN_WM_Double_RP_RX+: 12-15 Rp 1/2 Short; Type: 12-15 Rp 1/2 Short; Type Id: 1089447
Constraints - Elevation from Level: 0 mm; Level: REHAU Starting view; Moves With Nearby Elements: no
Data - PID Check: 1 mm
Dimensions - Area: 0.0143728 m2; Volume: 0.0000318082 m3
Identity Data - Description long: REHAU Double wall-mounted elbow RAU. RX+ 16/20 - Rp 1/2 short; GTIN: 4061264398308; PID: 14564161001; Weight: 171
Phasing - Phase Created: New Construction
Insulation - Insulation Thickness: 0 mm

# IfcFlowFitting: RAUTITAN_WM_Double_RP_RX+:15-12 Rp 1/2 Short, RAUTITAN_WM_Double_RP_RX+:15-12 Rp 1/2 Short:1087081
In: REHAU Starting view
Type - Material: RAUTITAN RX+
Type - Other - Category: Pipe Fittings; Family Name: RAUTITAN_WM_Double_RP_RX+; T1: RTI WM Double RP RX P1; T2: RTI WM Double RP RX
Type - Constraints - Default Elevation: 0 mm
Type - Data - Language: Description EN; Region Check: Check DE; Region PID: PID DE; Type: Short
Type - Dimensions - Di1: 12.5 mm; Di2: 9.9 mm; Di3: 20.4 mm; Di4: 13.1 mm; DN1: 15 mm; DN2: 12 mm; DN3: 15 mm; Do3: 26 mm; L4: 24.8 mm; L5: 39 mm; r1: 13 mm; r2: 10.2 mm; r3: 25 mm; Z4: 9 mm; Z5: 17.1 mm
Type - Identity Data - Classification Number: 23.60.30.11.14; Manufacturer: REHAU; Model: RAUTITAN; Type Name: 15-12 Rp 1/2 Short
Type - Pset_ManufacturerTypeInformation - Manufacturer: REHAU
Pset_DistributionFlowElementCommon - Reference: RAUTITAN_WM_Double_RP_RX+:15-12 Rp 1/2 Short; sets with these values: 2
Other - IsCustom: no; Family: RAUTITAN_WM_Double_RP_RX+; Family and Type: RAUTITAN_WM_Double_RP_RX+: 15-12 Rp 1/2 Short; Type: 15-12 Rp 1/2 Short; Type Id: 1089449
Constraints - Elevation from Level: 0 mm; Level: REHAU Starting view; Moves With Nearby Elements: no
Data - PID Check: 1 mm
Dimensions - Area: 0.0143728 m2; Volume: 0.0000318082 m3
Identity Data - Description long: REHAU Double wall-mounted elbow RAU. RX+ 20/16 - Rp 1/2 short; GTIN: 4061264398315; PID: 14564171001; Weight: 171
Phasing - Phase Created: New Construction
Insulation - Insulation Thickness: 0 mm

# IfcFlowFitting: RAUTITAN_WM_Double_RP_RX+:15-15 Rp 1/2 Long, RAUTITAN_WM_Double_RP_RX+:15-15 Rp 1/2 Long:1087051
In: REHAU Starting view
Type - Material: RAUTITAN RX+
Type - Other - Category: Pipe Fittings; Family Name: RAUTITAN_WM_Double_RP_RX+; T1: RTI WM Double RP RX P1; T2: RTI WM Double RP RX
Type - Constraints - Default Elevation: 0 mm
Type - Data - Language: Description EN; Region Check: Check DE; Region PID: PID DE; Type: Long
Type - Dimensions - Di1: 12.5 mm; Di2: 12.5 mm; Di3: 20.4 mm; Di4: 13.1 mm; DN1: 15 mm; DN2: 15 mm; DN3: 15 mm; Do3: 26 mm; L4: 41.8 mm; L5: 56 mm; r1: 13 mm; r2: 10.2 mm; r3: 25 mm; Z4: 9 mm; Z5: 17.1 mm
Type - Identity Data - Classification Number: 23.60.30.11.14; Manufacturer: REHAU; Model: RAUTITAN; Type Name: 15-15 Rp 1/2 Long
Type - Pset_ManufacturerTypeInformation - Manufacturer: REHAU
Pset_DistributionFlowElementCommon - Reference: RAUTITAN_WM_Double_RP_RX+:15-15 Rp 1/2 Long; sets with these values: 2
Other - IsCustom: no; Family: RAUTITAN_WM_Double_RP_RX+; Family and Type: RAUTITAN_WM_Double_RP_RX+: 15-15 Rp 1/2 Long; Type: 15-15 Rp 1/2 Long; Type Id: 1089441
Constraints - Elevation from Level: 0 mm; Level: REHAU Starting view; Moves With Nearby Elements: no
Data - PID Check: 1 mm
Dimensions - Area: 0.0161559 m2; Volume: 0.0000367897 m3
Identity Data - Description long: REHAU Double wall-mounted elbow RAU. RX+ 20/20 - Rp 1/2 long; GTIN: 4061264396915; PID: 14562711001; Weight: 171
Phasing - Phase Created: New Construction
Insulation - Insulation Thickness: 0 mm

# IfcFlowFitting: RAUTITAN_WM_Double_RP_RX+:15-15 Rp 1/2 Short, RAUTITAN_WM_Double_RP_RX+:15-15 Rp 1/2 Short:1087057
In: REHAU Starting view
Type - Material: RAUTITAN RX+
Type - Other - Category: Pipe Fittings; Family Name: RAUTITAN_WM_Double_RP_RX+; T1: RTI WM Double RP RX P1; T2: RTI WM Double RP RX
Type - Constraints - Default Elevation: 0 mm
Type - Data - Language: Description EN; Region Check: Check DE; Region PID: PID DE; Type: Short
Type - Dimensions - Di1: 12.5 mm; Di2: 12.5 mm; Di3: 20.4 mm; Di4: 13.1 mm; DN1: 15 mm; DN2: 15 mm; DN3: 15 mm; Do3: 26 mm; L4: 24.8 mm; L5: 39 mm; r1: 13 mm; r2: 10.2 mm; r3: 25 mm; Z4: 9 mm; Z5: 17.1 mm
Type - Identity Data - Classification Number: 23.60.30.11.14; Manufacturer: REHAU; Model: RAUTITAN; Type Name: 15-15 Rp 1/2 Short
Type - Pset_ManufacturerTypeInformation - Manufacturer: REHAU
Pset_DistributionFlowElementCommon - Reference: RAUTITAN_WM_Double_RP_RX+:15-15 Rp 1/2 Short; sets with these values: 2
Other - IsCustom: no; Family: RAUTITAN_WM_Double_RP_RX+; Family and Type: RAUTITAN_WM_Double_RP_RX+: 15-15 Rp 1/2 Short; Type: 15-15 Rp 1/2 Short; Type Id: 1089439
Constraints - Elevation from Level: 0 mm; Level: REHAU Starting view; Moves With Nearby Elements: no
Data - PID Check: 1 mm
Dimensions - Area: 0.0149169 m2; Volume: 0.0000333053 m3
Identity Data - Description long: REHAU Double wall-mounted elbow RAU. RX+ 20/20 - Rp 1/2 short; GTIN: 4061264398186; PID: 14564041001; Weight: 171
Phasing - Phase Created: New Construction
Insulation - Insulation Thickness: 0 mm

# IfcFlowFitting: RAUTITAN_WM_Double_RP_RX+:20-20 Rp 1/2 Long, RAUTITAN_WM_Double_RP_RX+:20-20 Rp 1/2 Long:1087063
In: REHAU Starting view
Type - Material: RAUTITAN RX+
Type - Other - Category: Pipe Fittings; Family Name: RAUTITAN_WM_Double_RP_RX+; T1: RTI WM Double RP RX P1; T2: RTI WM Double RP RX
Type - Constraints - Default Elevation: 0 mm
Type - Data - Language: Description EN; Region Check: Check DE; Region PID: PID DE; Type: Long
Type - Dimensions - Di1: 15.2 mm; Di2: 15.2 mm; Di3: 20.4 mm; Di4: 13.1 mm; DN1: 20 mm; DN2: 20 mm; DN3: 15 mm; Do3: 26 mm; L4: 40.1 mm; L5: 56 mm; r1: 13 mm; r2: 10.2 mm; r3: 25 mm; Z4: 9 mm; Z5: 17.1 mm
Type - Identity Data - Classification Number: 23.60.30.11.14; Manufacturer: REHAU; Model: RAUTITAN; Type Name: 20-20 Rp 1/2 Long
Type - Pset_ManufacturerTypeInformation - Manufacturer: REHAU
Pset_DistributionFlowElementCommon - Reference: RAUTITAN_WM_Double_RP_RX+:20-20 Rp 1/2 Long; sets with these values: 2
Other - IsCustom: no; Family: RAUTITAN_WM_Double_RP_RX+; Family and Type: RAUTITAN_WM_Double_RP_RX+: 20-20 Rp 1/2 Long; Type: 20-20 Rp 1/2 Long; Type Id: 1089445
Constraints - Elevation from Level: 0 mm; Level: REHAU Starting view; Moves With Nearby Elements: no
Data - PID Check: 1 mm
Dimensions - Area: 0.0181348 m2; Volume: 0.0000439902 m3
Identity Data - Description long: REHAU Double wall-mounted elbow RAU. RX+ 25/25 - Rp 1/2 long; GTIN: 4061264398360; PID: 14564221001; Weight: 171
Phasing - Phase Created: New Construction
Insulation - Insulation Thickness: 0 mm

# IfcFlowFitting: RAUTITAN_WM_Double_RP_RX+:20-20 Rp 1/2 Short, RAUTITAN_WM_Double_RP_RX+:20-20 Rp 1/2 Short:1087069
In: REHAU Starting view
Type - Material: RAUTITAN RX+
Type - Other - Category: Pipe Fittings; Family Name: RAUTITAN_WM_Double_RP_RX+; T1: RTI WM Double RP RX P1; T2: RTI WM Double RP RX
Type - Constraints - Default Elevation: 0 mm
Type - Data - Language: Description EN; Region Check: Check DE; Region PID: PID DE; Type: Short
Type - Dimensions - Di1: 15.2 mm; Di2: 15.2 mm; Di3: 20.4 mm; Di4: 13.1 mm; DN1: 20 mm; DN2: 20 mm; DN3: 15 mm; Do3: 26 mm; L4: 28.1 mm; L5: 44 mm; r1: 13 mm; r2: 10.2 mm; r3: 25 mm; Z4: 9 mm; Z5: 17.1 mm
Type - Identity Data - Classification Number: 23.60.30.11.14; Manufacturer: REHAU; Model: RAUTITAN; Type Name: 20-20 Rp 1/2 Short
Type - Pset_ManufacturerTypeInformation - Manufacturer: REHAU
Pset_DistributionFlowElementCommon - Reference: RAUTITAN_WM_Double_RP_RX+:20-20 Rp 1/2 Short; sets with these values: 2
Other - IsCustom: no; Family: RAUTITAN_WM_Double_RP_RX+; Family and Type: RAUTITAN_WM_Double_RP_RX+: 20-20 Rp 1/2 Short; Type: 20-20 Rp 1/2 Short; Type Id: 1089443
Constraints - Elevation from Level: 0 mm; Level: REHAU Starting view; Moves With Nearby Elements: no
Data - PID Check: 1 mm
Dimensions - Area: 0.0172602 m2; Volume: 0.0000415308 m3
Identity Data - Description long: REHAU Double wall-mounted elbow RAU. RX+ 25/25 - Rp 1/2 short; GTIN: 4061264398353; PID: 14564211001; Weight: 171
Phasing - Phase Created: New Construction
Insulation - Insulation Thickness: 0 mm

# IfcFlowFitting: RE.GUARD:RGD, RE.GUARD:RGD:1356245
In: REHAU Starting view
Type - Material: RAUTITAN RX+, Acrylester-Styrol-Acrylnitril
Type - Other - Category: Pipe Fittings; Family Name: RE.GUARD
Type - Constraints - Default Elevation: 0 mm
Type - Data - Language: Description EN; Region Check: Check DE; Region PID: PID DE
Type - Identity Data - Assembly Code: D2090800; Manufacturer: REHAU; Model: RE.GUARD 2.0; REHAU Info: 2024.05.06-419114-419114; Type Name: RGD; URL: https://oxomi.com/p/3000126/datasheet/-/14570001001?oxDeeplink=ewAiAG8AdgBlAHIAbABhAHkAIgA6AHsAIgB0AHkAcABlACIAOgAiAG8AcABlAG4ARABvAGMAdQBtAGUAbgB0ACIALAAiAGEAcgBnAHMAIgA6AHsAIgBkAG8AYwB1AG0AZQBuAHQAIgA6ACIAMQAwADUAMwA0ADAAMAA0ACIALAAiAHAAYQBnAGUATgB1AG0AYgBlAHIAIgA6ADcAMQAsACIAcwBpAG4AZwBsAGUAUABhAGcAZQAiADoAdAByAHUAZQAsACIAcQB1AGUAcgB5ACIAOgAiADEANAA1ADcAMAAwADAAMQAwADAAMQAgAE8AUgAgAFIARQAuAEcAVQBBAFIARAAgADIALgAwACAAVwBhAHMAcwBlAHIAcwB0AGUAdQBlAHIAdQBuAGcAIABPAFIAIAA0ADAANgA0ADIAOQA5ADcANAAyADkANAA4ACIALAAiAGUAeAB0AGUAcgBuAGEAbABMAGkAbgBrAHMARQBuAGEAYgBsAGUAZAAiADoAdAByAHUAZQAsACIAcABhAGcAZQAiADoANwAxAH0AfQB9AA%3D%3D
Type - Pset_ManufacturerTypeInformation - Manufacturer: REHAU
Classification: D2090800 (Uniformat)
Pset_DistributionFlowElementCommon - Reference: RE.GUARD:RGD; sets with these values: 2
Other - IsCustom: no; Family: RE.GUARD; Family and Type: RE.GUARD: RGD; Type: RGD; Type Id: 1356222
Constraints - Elevation from Level: 0 mm; Level: REHAU Starting view
Data - PID Check: 1 mm
Dimensions - a: 55 mm; Area: 0.0589671 m2; b: 141 mm; c: 38.5 mm; DN1: 20 mm; DN2: 20 mm; h1: 76 mm; h2: 113 mm; l: 190 mm; Maximum Size: 20 mm; Minimum Size: 20 mm; R: 38 deg; Size: 20 mmø-20 mmø; t: 77 mm; t/2: 38.5 mm; Volume: 0.00189825 m3
Graphics - Use Annotation Scale: no
Identity Data - Description long: RE.GUARD Water Control 2.0 DN 20 - G1, WiFi; ETIM Class code: EC003025; GTIN: 4064299742948; PID: 14570001001; Weight: 2200
Mechanical - System Classification: Undefined
Phasing - Phase Created: New Construction
Insulation - Insulation Thickness: 0 mm; Overall Size: 20 mmø-20 mmø

# IfcFlowFitting: REHAU_RAUTITAN_Adaptor RX+, MeplaFix:REHAU_RAUTITAN_Adaptor RX+, MeplaFix (2)
In: REHAU Starting view
Type - Material: PX, RX
Type - Other - Category: Pipe Fittings; Family Name: REHAU_RAUTITAN_Adaptor RX+, MeplaFix
Type - Constraints - Default Elevation: 0 mm
Type - Identity Data - ETIM_CLASS: EC003024; ETIM_MODELLING_CLASS: N/A; REH_BIM_SUPPORT: bim@rehau.com; REH_INFO: 2023.12.18-419114-419114; REH_PRICE_LIST: DE_2023; REH_PRODUCT_PICTURE: https://static.rehau.com/bim/images/1000/jpg/M-52546.jpg; Type Name: REHAU_RAUTITAN_Adaptor RX+, MeplaFix
Type - Materials and Finishes - REH_MATERIAL: RX
Pset_DistributionFlowElementCommon - Reference: REHAU_RAUTITAN_Adaptor RX+, MeplaFix:REHAU_RAUTITAN_Adaptor RX+, MeplaFix; sets with these values: 2
Other - a: 1.97 mm; Family: REHAU_RAUTITAN_Adaptor RX+, MeplaFix; Family and Type: REHAU_RAUTITAN_Adaptor RX+, MeplaFix: REHAU_RAUTITAN_Adaptor RX+, MeplaFix; Type: REHAU_RAUTITAN_Adaptor RX+, MeplaFix; Type Id: 1089317
Constraints - Elevation from Level: 0 mm; Level: REHAU Starting view
Dimensions - Area: 0.0041524 m2; Do1: 16 mm; Dr1: 21.7 mm; t1: 2.6 mm; Z1: 7.65 mm; Z2: 8.4 mm
Graphics - Use Annotation Scale: no
Identity Data - REH_DESCRIPTION_LANGUAGE: Language : EN
Mechanical - System Classification: Undefined
Phasing - Phase Created: New Construction
Insulation - Insulation Thickness: 0 mm
Name (REHAU_RAUTITAN_Adaptor RX+, MeplaFix:REHAU_RAUTITAN_Adaptor RX+, MeplaFix:...) | Nominal Diameter 1 (mm) = Nominal Diameter 2 (mm) = DN1 (mm) = DN2 (mm) = Maximum Size (mm) = Minimum Size (mm) | Do2 (mm) | Dr2 (mm) | L1 (mm) | L2 (mm) | Size = Overall Size | t2 (mm) | Volume (m3) | PID = REH_SUPPLIER_PID | REH_DESCRIPTION_SHORT | REH_DIMENSION | REH_GTIN | REH_NETWEIGHT_G/PC | REH_NOMINAL_DIAMETER
1441967 | 12 | 16 | 22.5 | 26.05 | 23.75 | 12 mmø-12 mmø | 2.87 | 0.0000159398 | 14564051001 | REHAU Adaptor RAUTITAN RX+ 16 - MeplaFix | 16 - MeplaFix | 4061264398193 | 67 | DN 12/MeplaFix
1442034 | 15 | 20 | 26.5 | 28.64 | 28.24 | 15 mmø-15 mmø | 3.35 | 0.0000187222 | 14564101001 | REHAU Adapter RAUTITAN RX+ 20 - MeplaFix | 20 - MeplaFix | 4061264398247 | 79 | DN 15/MeplaFix

# IfcFlowFitting: REHAU_RAUTITAN_Adaptor_RX+ stabil, with external thread:REHAU_RAUTITAN_Adaptor_RX+ stabil, with external thread (2)
In: REHAU Starting view
Type - Material: RX
Type - Other - Category: Pipe Fittings; Family Name: REHAU_RAUTITAN_Adaptor_RX+ stabil, with external thread
Type - Constraints - Default Elevation: 0 mm
Type - Identity Data - ETIM_CLASS: EC003024; ETIM_MODELLING_CLASS: MC000012; Manufacturer: "REHAU"; REH_BIM_SUPPORT: bim@rehau.com; REH_INFO: 2024.04.15-419114-419114; REH_PRICE_LIST: DE_2024; REH_PRODUCT_PICTURE: https://static.rehau.com/bim/images/1000/jpg/M-52322.jpg; Type Name: REHAU_RAUTITAN_Adaptor_RX+ stabil, with external thread
Type - Materials and Finishes - REH_MATERIAL: RX
Type - Pset_ManufacturerTypeInformation - Manufacturer: "REHAU"
Pset_DistributionFlowElementCommon - Reference: REHAU_RAUTITAN_Adaptor_RX+ stabil, with external thread:REHAU_RAUTITAN_Adaptor_RX+ stabil, with external thread; sets with these values: 2
Other - Family: REHAU_RAUTITAN_Adaptor_RX+ stabil, with external thread; Family and Type: REHAU_RAUTITAN_Adaptor_RX+ stabil, with external thread: REHAU_RAUTITAN_Adaptor_RX+ stabil, with external thread; Type: REHAU_RAUTITAN_Adaptor_RX+ stabil, with external thread; Type 0: yes; Type 1: no; Type Id: 1089346
Constraints - Elevation from Level: 0 mm; Level: REHAU Starting view
Dimensions - A: 45 deg; Area: 0.0041524 m2
Graphics - Use Annotation Scale: no
Identity Data - REH_DESCRIPTION_LANGUAGE: Language : EN
Mechanical - System Classification: Undefined
Phasing - Phase Created: New Construction
Insulation - Insulation Thickness: 0 mm
Name (REHAU_RAUTITAN_Adaptor_RX+ stabil, with external thread:REHAU_RAUTITAN_Adaptor_RX+ stabil, with external thread:...) | SWL (mm) | Nominal Diameter 1 (mm) = Nominal Diameter 2 (mm) = DN1 (mm) = DN2 (mm) = Maximum Size (mm) = Minimum Size (mm) | Do1 (mm) | Dr1 (mm) | L1 (mm) | L2 (mm) | Size = Overall Size | t1 (mm) | t2 (mm) | Volume (m3) | Z1 (mm) | Z2 (mm) | PID = REH_SUPPLIER_PID | REH_DESCRIPTION_SHORT | REH_DIMENSION | REH_GTIN | REH_NETWEIGHT_G/PC | REH_NOMINAL_DIAMETER
1443065 | 50 | 40 | 43.1 | 61 | 56.9 | 27.2 | 40 mmø-40 mmø | 6.4 | 1.5 | 0.0000603138 | 15.6 | 9.5 | 14600611001 | REHAU Adaptor RAUTITAN RX+ stabil 50 - R 1 1/2 | 50 - R 1 1/2 | 4062178676117 | 49.9 | DN 40/40
1443069 | 54.5 | 50 | 54.5 | 74 | 58.3 | 41.5 | 50 mmø-50 mmø | 7.9 | 1 | 0.0000934089 | 7.9 | 20 | 14600621001 | REHAU Adaptor RAUTITAN RX+ stabil 63 - R 2 | 63 - R 2 | 4062178676124 | 78.1 | DN 50/50

# IfcFlowFitting: REHAU_RAUTITAN_Adaptor_RX+, with internal thread:REHAU_RAUTITAN_Adaptor_RX+, with internal thread (9)
In: REHAU Starting view
Type - Material: RX
Type - Other - Category: Pipe Fittings; Family Name: REHAU_RAUTITAN_Adaptor_RX+, with internal thread
Type - Constraints - Default Elevation: 0 mm
Type - Identity Data - ETIM_CLASS: EC003024; ETIM_MODELLING_CLASS: MC000012; Manufacturer: REHAU; REH_BIM_SUPPORT: bim@rehau.com; REH_INFO: 2023.09.29-416508-416508; REH_PRICE_LIST: DE_2023; REH_PRODUCT_PICTURE: https://static.rehau.com/bim/images/1000/jpg/M-52314.jpg; Type Name: REHAU_RAUTITAN_Adaptor_RX+, with internal thread
Type - Materials and Finishes - REH_MATERIAL: RX
Type - Pset_ManufacturerTypeInformation - Manufacturer: REHAU
Pset_DistributionFlowElementCommon - Reference: REHAU_RAUTITAN_Adaptor_RX+, with internal thread:REHAU_RAUTITAN_Adaptor_RX+, with internal thread; sets with these values: 2
Other - IsCustom: no; Family: REHAU_RAUTITAN_Adaptor_RX+, with internal thread; Family and Type: REHAU_RAUTITAN_Adaptor_RX+, with internal thread: REHAU_RAUTITAN_Adaptor_RX+, with internal thread; Type: REHAU_RAUTITAN_Adaptor_RX+, with internal thread; Type Id: 1089319
Constraints - Elevation from Level: 0 mm; Level: REHAU Starting view
Dimensions - Area: 0.0041524 m2
Graphics - Use Annotation Scale: no
Identity Data - REH_DESCRIPTION_LANGUAGE: Language : EN
Mechanical - System Classification: Undefined
Phasing - Phase Created: New Construction
Insulation - Insulation Thickness: 0 mm
Name (REHAU_RAUTITAN_Adaptor_RX+, with internal thread:REHAU_RAUTITAN_Adaptor_RX+, with internal thread:...) | Nominal Diameter 1 (mm) = DN1 (mm) | Nominal Diameter 2 (mm) = DN2 (mm) | Do1 (mm) | Dr1 (mm) | h (mm) | L1 (mm) | L2 (mm) | Maximum Size (mm) | Minimum Size (mm) | Size = Overall Size | SWL (mm) | t1 (mm) | Volume (m3) | Z1 (mm) | Z2 (mm) | PID = REH_SUPPLIER_PID | REH_DESCRIPTION_SHORT | REH_DIMENSION | REH_GTIN | REH_NETWEIGHT_G/PC | REH_NOMINAL_DIAMETER
1443667 | 12 | 15 | 16 | 22.5 | 8.7 | 31.49 | 12.6 | 15 | 12 | 15 mmø-12 mmø | 25 | 3.3 | 0.00000648753 | 15.99 | 4.61 | 14563271001 | REHAU Adaptor RAUTITAN RX+ 16 - Rp 1/2 | 16 - Rp 1/2 | 4061264397417 | 56 | DN 12 / 15
1443731 | 15 | 15 | 20 | 26.5 | 8.7 | 34.69 | 12.61 | 15 | 15 | 15 mmø-15 mmø | 25 | 3.8 | 0.00000786598 | 15.19 | 4.61 | 14563281001 | REHAU Adaptor RAUTITAN RX+ 20 - Rp 1/2 | 20 - Rp 1/2 | 4061264397424 | 67 | DN 15 / 15
1443735 | 15 | 20 | 20 | 26.5 | 8.82 | 37.1 | 13.2 | 20 | 15 | 20 mmø-15 mmø | 31 | 3.83 | 0.0000114159 | 17.6 | 4.2 | 14563291001 | REHAU Adaptor RAUTITAN RX+ 20 - Rp 3/4 | 20 - Rp 3/4 | 4061264397431 | 86 | DN 15 / 20
1443739 | 20 | 15 | 25 | 33.59 | 9 | 44.56 | 14.64 | 20 | 15 | 20 mmø-15 mmø | 25 | 4.21 | 0.0000118385 | 17.57 | 4.64 | 14563301001 | REHAU Adaptor RAUTITAN RX+ 25 - Rp 1/2 | 25 - Rp 1/2 | 4061264397448 | 82 | DN 20 / 15
1443743 | 20 | 20 | 25 | 33.59 | 8.11 | 43.57 | 14.63 | 20 | 20 | 20 mmø-20 mmø | 31 | 4.21 | 0.0000147198 | 16.58 | 4.62 | 14563311001 | REHAU Adaptor RAUTITAN RX+ 25 - Rp 3/4 | 25 - Rp 3/4 | 4061264397455 | 110 | DN 20 / 20
1443747 | 25 | 20 | 32 | 40 | 11 | 48.36 | 15.64 | 25 | 20 | 25 mmø-20 mmø | 31 | 5.09 | 0.000020633 | 16.36 | 4.64 | 14563321001 | REHAU Adaptor RAUTITAN RX+ 32 - Rp 3/4 | 32 - Rp 3/4 | 4061264397462 | 124 | DN 25 / 20
1443751 | 25 | 25 | 32 | 40 | 10.68 | 50.94 | 16.06 | 25 | 25 | 25 mmø-25 mmø | 39 | 5 | 0.0000277887 | 18.94 | 6.06 | 14563331001 | REHAU Adaptor RAUTITAN RX+ 32 - Rp 1 | 32 - Rp 1 | 4061264397479 | 188 | DN 25 / 25
1443755 | 32 | 32 | 40 | 49 | 10.31 | 56.98 | 18.02 | 32 | 32 | 32 mmø-32 mmø | 49 | 9 | 0.0000543535 | 24.98 | 6.02 | 14563341001 | REHAU Adaptor RAUTITAN RX+ 40 - Rp 1 1/4 | 40 - Rp 1 1/4 | 4061264397486 | 349 | DN 32 / 32
1443803 | 20 | 25 | 25 | 33.59 | 8.38 | 46.15 | 16.05 | 25 | 20 | 25 mmø-20 mmø | 38 | 4.21 | 0.000020555 | 19.16 | 5.05 | 14564081001 | REHAU Adaptor RAUTITAN RX+ 25 - Rp 1 | 25 - Rp 1 | 4061264398223 | 155 | DN 20 / 25

# IfcFlowFitting: REHAU_RAUTITAN_Adaptor_RX+_union nut:REHAU_RAUTITAN_Adaptor_RX+_union nut (12)
In: REHAU Starting view
Type - Material: RX
Type - Other - Category: Pipe Fittings; Family Name: REHAU_RAUTITAN_Adaptor_RX+_union nut
Type - Constraints - Default Elevation: 0 mm
Type - Identity Data - ETIM_CLASS: EC003024; ETIM_MODELLING_CLASS: MC000012; Manufacturer: "REHAU"; REH_BIM_SUPPORT: bim@rehau.com; REH_INFO: 2024.02.07-419114-419114; REH_PRICE_LIST: DE_2024; REH_PRODUCT_PICTURE: https://static.rehau.com/bim/images/1000/jpg/M-52485.jpg; Type Name: REHAU_RAUTITAN_Adaptor_RX+_union nut
Type - Materials and Finishes - REH_MATERIAL: RX
Type - Pset_ManufacturerTypeInformation - Manufacturer: "REHAU"
Pset_DistributionFlowElementCommon - Reference: REHAU_RAUTITAN_Adaptor_RX+_union nut:REHAU_RAUTITAN_Adaptor_RX+_union nut; sets with these values: 2
Other - IsCustom: no; Family: REHAU_RAUTITAN_Adaptor_RX+_union nut; Family and Type: REHAU_RAUTITAN_Adaptor_RX+_union nut: REHAU_RAUTITAN_Adaptor_RX+_union nut; Type: REHAU_RAUTITAN_Adaptor_RX+_union nut; Type Id: 1089321
Constraints - Elevation from Level: 0 mm; Level: REHAU Starting view
Dimensions - Area: 0.0041524 m2
Graphics - Use Annotation Scale: no
Identity Data - REH_DESCRIPTION_LANGUAGE: Language : EN
Mechanical - System Classification: Undefined
Phasing - Phase Created: New Construction
Insulation - Insulation Thickness: 0 mm
Name (REHAU_RAUTITAN_Adaptor_RX+_union nut:REHAU_RAUTITAN_Adaptor_RX+_union nut:...) | ID A (mm) | ID outside (mm) | SWL (mm) | SWL / 2 (mm) | Type 0 | Type 1 | Nominal Diameter 1 (mm) = DN1 (mm) = Minimum Size (mm) | Nominal Diameter 2 (mm) = DN2 (mm) = Do2 (mm) = Maximum Size (mm) | A (deg) | Do1 (mm) | Dr1 (mm) | Dr2 (mm) | L1 (mm) | L2 (mm) | L G (mm) | L Swivel Nut (mm) | Size = Overall Size | t1 (mm) | t2 (mm) | Volume (m3) | Z1 (mm) | REH_NETWEIGHT_G/PC | PID = REH_SUPPLIER_PID | REH_DESCRIPTION_SHORT | REH_DIMENSION | REH_GTIN | REH_NOMINAL_DIAMETER
1444898 | 22.2 | 25.3 | 26 | 13 | no | yes | 12 | 15 | 60 | 16 | 22.5 | 16 | 23.75 | 8.05 | 6.5 | 5.05 | 15 mmø-12 mmø | 3 | 3 | 0.00000767936 | 8 | 56 | 14563351001 | REHAU Adaptor RAUTITAN RX+, 16 - G 1/2 | 16 - G 1/2 | 4061264397493 | DN 12/15
1444958 | 27 | 29 | 30 | 15 | no | yes | 12 | 20 | 60 | 16 | 22.5 | 16 | 23 | 11 | 9.5 | 8 | 20 mmø-12 mmø | 3 | 3 | 0.0000101501 | 7.5 | 69 | 14563361001 | REHAU Adaptor RAUTITAN RX+, 16 - G 3/4 | 16 - G 3/4 | 4061264397509 | DN 12/20
1444962 | 22.2 | 25.3 | 26 | 13 | no | yes | 15 | 15 | 60 | 20 | 26.5 | 16 | 31 | 10 | 6.5 | 7 | 15 mmø-15 mmø | 3.35 | 3 | 0.00000973397 | 11.09 | 76 | 14563371001 | REHAU Adaptor RAUTITAN RX+, 20 - G 1/2 | 20 - G 1/2 | 4061264397516 | DN 15/15
1444966 | 27 | 29 | 30 | 15 | no | yes | 15 | 20 | 60 | 20 | 26.5 | 20 | 27.75 | 10.45 | 9.5 | 7.45 | 20 mmø-15 mmø | 3.35 | 3 | 0.0000110177 | 7.9 | 81 | 14563381001 | REHAU Adaptor RAUTITAN RX+, 20 - G 3/4 | 20 - G 3/4 | 4061264397523 | DN 15/20
1444970 | 27 | 29 | 30 | 15 | no | yes | 20 | 20 | 60 | 25 | 33.6 | 21 | 40 | 12 | 9.5 | 9 | 20 mmø-20 mmø | 3.5 | 3 | 0.000015616 | 12.35 | 116 | 14563391001 | REHAU Adaptor RAUTITAN RX+, 25 - G 3/4 | 25 - G 3/4 | 4061264397530 | DN 20/20
1444974 | 33.8 | 37 | 38 | 19 | no | yes | 20 | 25 | 60 | 25 | 33.6 | 27.6 | 37 | 12 | 12.5 | 9 | 25 mmø-20 mmø | 3.5 | 3 | 0.0000198474 | 9.65 | 145 | 14563401001 | REHAU Adaptor RAUTITAN RX+, 25 - G 1 | 25 - G 1 | 4061264397547 | DN 20/25
1444978 | 33.8 | 37 | 38 | 19 | no | yes | 25 | 25 | 60 | 32 | 40 | 27.6 | 44 | 11 | 12.5 | 8 | 25 mmø-25 mmø | 4.35 | 3 | 0.0000260499 | 12 | 190 | 14563411001 | REHAU Adaptor RAUTITAN RX+, 32 - G 1 | 32 - G 1 | 4061264397554 | DN 25/25
1444982 | 42.2 | 45 | 46 | 23 | no | yes | 25 | 32 | 60 | 32 | 40 | 32 | 43 | 12 | 11.1 | 9 | 32 mmø-25 mmø | 4.4 | 3 | 0.0000352498 | 10.5 | 238 | 14563421001 | REHAU Adaptor RAUTITAN RX+, 32 - G 1 1/4 | 32 - G 1 1/4 | 4061264397561 | DN 25/32
1444986 | 41 | 47.8 | 52 | 26 | yes | no | 25 | 40 | 45 | 32 | 40 | 32 | 40 | 12 | 19 | 8 | 40 mmø-25 mmø | 4.4 | 4 | 0.0000348339 | 8 | 244 | 14563431001 | REHAU Adaptor RAUTITAN RX+, 32 - G 1 1/2 | 32 - G 1 1/2 | 4061264397578 | DN 25/40
1444990 | 39.2 | 47.8 | 52 | 26 | yes | no | 32 | 40 | 45 | 40 | 49 | 30 | 49 | 11 | 19 | 7.6 | 40 mmø-32 mmø | 4.6 | 3.4 | 0.0000566522 | 13.2 | 362 | 14563441001 | REHAU Adaptor RAUTITAN RX+, 40 - G 1 1/2 | 40 - G 1 1/2 | 4061264397585 | DN 32/40
1444994 | 45.1 | 51 | 60 | 30 | yes | no | 40 | 40 | 45 | 50 | 61 | 35 | 56 | 11 | 19 | 7.6 | 40 mmø-40 mmø | 4.45 | 3.4 | 0.0000733021 | 13 | 522 | 14563451001 | REHAU Adaptor RAUTITAN RX+, 50 - G 1 3/4 | 50 - G 1 3/4 | 4061264397592 | DN 40/40
1444998 | 62.9 | 67 | 74 | 37 | yes | no | 50 | 50 | 45 | 63 | 74 | 45.2 | 68 | 14 | 22 | 10.4 | 50 mmø-50 mmø | 6.6 | 3.6 | 0.000117672 | 16.2 | 822 | 14563461001 | REHAU Adaptor RAUTITAN RX+, 63 -G 2 3/8 | 63 - G 2 3/8 | 4061264397608 | DN 50/50

# IfcFlowFitting: REHAU_RAUTITAN_Bend-T-piece_RX+:REHAU_RAUTITAN_T-piece_RX+ (3)
In: REHAU Starting view
Type - Material: RX
Type - Other - Category: Pipe Fittings; Family Name: REHAU_RAUTITAN_Bend-T-piece_RX+
Type - Constraints - Default Elevation: 0 mm
Type - Identity Data - Classification Number: 23.27.43.00; ETIM_CLASS: EC003025; ETIM_MODELLING_CLASS: MC000017; Manufacturer: REHAU; REH_BIM_SUPPORT: bim@rehau.com; REH_INFO: 2023.12.06-419114-419114; REH_PRICE_LIST: DE_2024; REH_PRODUCT_PICTURE: https://static.rehau.com/bim/images/1000/jpg/M-103172.jpg; Type Name: REHAU_RAUTITAN_T-piece_RX+
Type - Materials and Finishes - REH_MATERIAL: RX
Type - Pset_ManufacturerTypeInformation - Manufacturer: REHAU
Pset_DistributionFlowElementCommon - Reference: REHAU_RAUTITAN_Bend-T-piece_RX+:REHAU_RAUTITAN_T-piece_RX+; sets with these values: 2
Other - IsCustom: no; Family: REHAU_RAUTITAN_Bend-T-piece_RX+; Family and Type: REHAU_RAUTITAN_Bend-T-piece_RX+: REHAU_RAUTITAN_T-piece_RX+; Type: REHAU_RAUTITAN_T-piece_RX+; Type Id: 1089322
Constraints - Elevation from Level: 0 mm; Level: REHAU Starting view
Dimensions - a: 90 deg; Area: 0.000907516 m2; REH_ANGLE_CHECK: 90 deg
Graphics - Use Annotation Scale: no
Identity Data - REH_DESCRIPTION_LANGUAGE: Language : EN
Mechanical - System Classification: Undefined
Phasing - Phase Created: New Construction
Insulation - Insulation Thickness: 0 mm
Name (REHAU_RAUTITAN_Bend-T-piece_RX+:REHAU_RAUTITAN_T-piece_RX+:...) | Nominal Diameter 1 (mm) = DN1 (mm) | Nominal Diameter 2 (mm) = DN2 (mm) = Minimum Size (mm) | Nominal Diameter 3 (mm) = DN3 (mm) = Do1 (mm) = Maximum Size (mm) | Do2 (mm) | Do3 (mm) | Dr1 (mm) | Dr2 (mm) | Dr3 (mm) | L1 (mm) | L2 (mm) | L3 (mm) | Size = Overall Size | t1 (mm) | t2 (mm) | t3 (mm) | Volume (m3) | Z1 (mm) | Z2 (mm) | Z3 (mm) | PID = REH_SUPPLIER_PID | REH_DESCRIPTION_SHORT | REH_DIMENSION | REH_GTIN | REH_NETWEIGHT_G/PC | REH_NOMINAL_DIAMETER
1444902 | 20 | 12 | 25 | 16 | 32 | 33.6 | 22.5 | 40 | 50.46 | 52.3 | 56.74 | 25 mmø-20 mmø-12 mmø | 4.2 | 3.3 | 5.5 | 0.0000293268 | 23.46 | 36.8 | 24.74 | 14563971001 | REHAU Bend-T-piece RAUTITAN RX+ 32 - 16 - 25 | 32 - 16 - 25 | 4061264398117 | 272 | DN 25/12/20
1445002 | 25 | 12 | 32 | 16 | 40 | 40 | 22.5 | 49 | 57 | 54.8 | 66 | 32 mmø-25 mmø-12 mmø | 5 | 3.8 | 8.79 | 0.0000566449 | 25 | 39.3 | 34 | 14563981001 | REHAU Bend-T-piece RAUTITAN RX+ 40 - 16 - 32 | 40 - 16 - 32 | 4061264398124 | 448 | DN 32/12/25
1445010 | 25 | 15 | 32 | 20 | 40 | 40 | 26.5 | 49 | 57.5 | 56.3 | 61.5 | 32 mmø-25 mmø-15 mmø | 5 | 4.8 | 8.79 | 0.0000570675 | 25.5 | 36.8 | 29.5 | 14563991001 | REHAU Bend-T-piece RAUTITAN RX+ 40 - 20 - 32 | 40 - 20 - 32 | 4061264398131 | 461 | DN 32/15/25

# IfcFlowFitting: REHAU_RAUTITAN_Cap_RX+:REHAU_RAUTITAN_Cap_RX+ (2)
In: REHAU Starting view
Type - Material: RX
