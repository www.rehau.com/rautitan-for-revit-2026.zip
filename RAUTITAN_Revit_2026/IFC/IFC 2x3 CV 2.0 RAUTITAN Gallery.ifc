Properties of the parts of a building model (IFC2X3), part 8 of 9

# IfcFlowFitting: Sleeve:PX 7,4 (450)
Name (Sleeve:PX 7,4:...) | Language Tender Text | Region URL | DN1 (mm) | L1 (mm) | Volume (m3) | Description long | GTIN | PID | Product Group | Product URL | Weight
1078669 | Tender Text en | Product URL DE | 15 | 25 | 0.00000516767 | REHAU Compression sleeve RAUTITAN PX 20 | 4007360361211 | 11600021001 | 1949 | https://oxomi.com/p/3000126/datasheet/-/11600021001 | 0.011
1078671 | Tender Text en | Product URL DE | 12 | 23.7 | 0.00000312848 | REHAU Compression sleeve RAUTITAN PX 16 | 4007360361204 | 11600011001 | 1947 | https://oxomi.com/p/3000126/datasheet/-/11600011001 | 0.0076
1078673 | Tender Text en | Product URL DE | 20 | 27.2 | 0.0000087028 | REHAU Compression sleeve RAUTITAN PX 25 | 4007360361228 | 11600031001 | 1950 | https://oxomi.com/p/3000126/datasheet/-/11600031001 | 0.015828
1078675 | Tender Text en | Product URL DE | 12 | 23.7 | 0.00000312848 | REHAU Compression sleeve RAUTITAN PX 16 | 4007360361204 | 11600011001 | 1947 | https://oxomi.com/p/3000126/datasheet/-/11600011001 | 0.0076
1078677 | Tender Text en | Product URL DE | 15 | 25 | 0.00000516767 | REHAU Compression sleeve RAUTITAN PX 20 | 4007360361211 | 11600021001 | 1949 | https://oxomi.com/p/3000126/datasheet/-/11600021001 | 0.011
1078679 | Tender Text en | Product URL DE | 12 | 23.7 | 0.00000312848 | REHAU Compression sleeve RAUTITAN PX 16 | 4007360361204 | 11600011001 | 1947 | https://oxomi.com/p/3000126/datasheet/-/11600011001 | 0.0076
1078681 | Tender Text en | Product URL DE | 12 | 23.7 | 0.00000312848 | REHAU Compression sleeve RAUTITAN PX 16 | 4007360361204 | 11600011001 | 1947 | https://oxomi.com/p/3000126/datasheet/-/11600011001 | 0.0076
1078683 | Tender Text en | Product URL DE | 20 | 27.2 | 0.0000087028 | REHAU Compression sleeve RAUTITAN PX 25 | 4007360361228 | 11600031001 | 1950 | https://oxomi.com/p/3000126/datasheet/-/11600031001 | 0.015828
1078685 | Tender Text en | Product URL DE | 15 | 25 | 0.00000516767 | REHAU Compression sleeve RAUTITAN PX 20 | 4007360361211 | 11600021001 | 1949 | https://oxomi.com/p/3000126/datasheet/-/11600021001 | 0.011
1078687 | Tender Text en | Product URL DE | 15 | 25 | 0.00000516767 | REHAU Compression sleeve RAUTITAN PX 20 | 4007360361211 | 11600021001 | 1949 | https://oxomi.com/p/3000126/datasheet/-/11600021001 | 0.011
1078689 | Tender Text en | Product URL DE | 25 | 34 | 0.0000174355 | REHAU Compression sleeve RAUTITAN PX 32 | 4007360361235 | 11600041001 | 1951 | https://oxomi.com/p/3000126/datasheet/-/11600041001 | 0.027828
1078691 | Tender Text en | Product URL DE | 20 | 27.2 | 0.0000087028 | REHAU Compression sleeve RAUTITAN PX 25 | 4007360361228 | 11600031001 | 1950 | https://oxomi.com/p/3000126/datasheet/-/11600031001 | 0.015828
1078693 | Tender Text en | Product URL DE | 20 | 27.2 | 0.0000087028 | REHAU Compression sleeve RAUTITAN PX 25 | 4007360361228 | 11600031001 | 1950 | https://oxomi.com/p/3000126/datasheet/-/11600031001 | 0.015828
1078695 | Tender Text en | Product URL DE | 32 | 37.8 | 0.0000303041 | REHAU Compression sleeve RAUTITAN PX 40 | 4007360361242 | 11600051001 | 1952 | https://oxomi.com/p/3000126/datasheet/-/11600051001 | 0.03861
1078697 | Tender Text en | Product URL DE | 25 | 34 | 0.0000174355 | REHAU Compression sleeve RAUTITAN PX 32 | 4007360361235 | 11600041001 | 1951 | https://oxomi.com/p/3000126/datasheet/-/11600041001 | 0.027828
1078699 | Tender Text en | Product URL DE | 25 | 34 | 0.0000174355 | REHAU Compression sleeve RAUTITAN PX 32 | 4007360361235 | 11600041001 | 1951 | https://oxomi.com/p/3000126/datasheet/-/11600041001 | 0.027828
1078701 | Tender Text en | Product URL DE | 20 | 27.2 | 0.0000087028 | REHAU Compression sleeve RAUTITAN PX 25 | 4007360361228 | 11600031001 | 1950 | https://oxomi.com/p/3000126/datasheet/-/11600031001 | 0.015828
1078703 | Tender Text en | Product URL DE | 12 | 23.7 | 0.00000312848 | REHAU Compression sleeve RAUTITAN PX 16 | 4007360361204 | 11600011001 | 1947 | https://oxomi.com/p/3000126/datasheet/-/11600011001 | 0.0076
1078705 | Tender Text en | Product URL DE | 12 | 23.7 | 0.00000312848 | REHAU Compression sleeve RAUTITAN PX 16 | 4007360361204 | 11600011001 | 1947 | https://oxomi.com/p/3000126/datasheet/-/11600011001 | 0.0076
1078707 | Tender Text en | Product URL DE | 25 | 34 | 0.0000174355 | REHAU Compression sleeve RAUTITAN PX 32 | 4007360361235 | 11600041001 | 1951 | https://oxomi.com/p/3000126/datasheet/-/11600041001 | 0.027828
1078709 | Tender Text en | Product URL DE | 15 | 25 | 0.00000516767 | REHAU Compression sleeve RAUTITAN PX 20 | 4007360361211 | 11600021001 | 1949 | https://oxomi.com/p/3000126/datasheet/-/11600021001 | 0.011
1078711 | Tender Text en | Product URL DE | 15 | 25 | 0.00000516767 | REHAU Compression sleeve RAUTITAN PX 20 | 4007360361211 | 11600021001 | 1949 | https://oxomi.com/p/3000126/datasheet/-/11600021001 | 0.011
1078713 | Tender Text en | Product URL DE | 15 | 25 | 0.00000516767 | REHAU Compression sleeve RAUTITAN PX 20 | 4007360361211 | 11600021001 | 1949 | https://oxomi.com/p/3000126/datasheet/-/11600021001 | 0.011
1078715 | Tender Text en | Product URL DE | 15 | 25 | 0.00000516767 | REHAU Compression sleeve RAUTITAN PX 20 | 4007360361211 | 11600021001 | 1949 | https://oxomi.com/p/3000126/datasheet/-/11600021001 | 0.011
1078717 | Tender Text en | Product URL DE | 12 | 23.7 | 0.00000312848 | REHAU Compression sleeve RAUTITAN PX 16 | 4007360361204 | 11600011001 | 1947 | https://oxomi.com/p/3000126/datasheet/-/11600011001 | 0.0076
1078719 | Tender Text en | Product URL DE | 20 | 27.2 | 0.0000087028 | REHAU Compression sleeve RAUTITAN PX 25 | 4007360361228 | 11600031001 | 1950 | https://oxomi.com/p/3000126/datasheet/-/11600031001 | 0.015828
1078721 | Tender Text en | Product URL DE | 20 | 27.2 | 0.0000087028 | REHAU Compression sleeve RAUTITAN PX 25 | 4007360361228 | 11600031001 | 1950 | https://oxomi.com/p/3000126/datasheet/-/11600031001 | 0.015828
1078723 | Tender Text en | Product URL DE | 15 | 25 | 0.00000516767 | REHAU Compression sleeve RAUTITAN PX 20 | 4007360361211 | 11600021001 | 1949 | https://oxomi.com/p/3000126/datasheet/-/11600021001 | 0.011
1078725 | Tender Text en | Product URL DE | 25 | 34 | 0.0000174355 | REHAU Compression sleeve RAUTITAN PX 32 | 4007360361235 | 11600041001 | 1951 | https://oxomi.com/p/3000126/datasheet/-/11600041001 | 0.027828
1078727 | Tender Text en | Product URL DE | 25 | 34 | 0.0000174355 | REHAU Compression sleeve RAUTITAN PX 32 | 4007360361235 | 11600041001 | 1951 | https://oxomi.com/p/3000126/datasheet/-/11600041001 | 0.027828
1078729 | Tender Text en | Product URL DE | 20 | 27.2 | 0.0000087028 | REHAU Compression sleeve RAUTITAN PX 25 | 4007360361228 | 11600031001 | 1950 | https://oxomi.com/p/3000126/datasheet/-/11600031001 | 0.015828
1078731 | Tender Text en | Product URL DE | 20 | 27.2 | 0.0000087028 | REHAU Compression sleeve RAUTITAN PX 25 | 4007360361228 | 11600031001 | 1950 | https://oxomi.com/p/3000126/datasheet/-/11600031001 | 0.015828
1078733 | Tender Text en | Product URL DE | 20 | 27.2 | 0.0000087028 | REHAU Compression sleeve RAUTITAN PX 25 | 4007360361228 | 11600031001 | 1950 | https://oxomi.com/p/3000126/datasheet/-/11600031001 | 0.015828
1078735 | Tender Text en | Product URL DE | 12 | 23.7 | 0.00000312848 | REHAU Compression sleeve RAUTITAN PX 16 | 4007360361204 | 11600011001 | 1947 | https://oxomi.com/p/3000126/datasheet/-/11600011001 | 0.0076
1078737 | Tender Text en | Product URL DE | 25 | 34 | 0.0000174355 | REHAU Compression sleeve RAUTITAN PX 32 | 4007360361235 | 11600041001 | 1951 | https://oxomi.com/p/3000126/datasheet/-/11600041001 | 0.027828
1078739 | Tender Text en | Product URL DE | 25 | 34 | 0.0000174355 | REHAU Compression sleeve RAUTITAN PX 32 | 4007360361235 | 11600041001 | 1951 | https://oxomi.com/p/3000126/datasheet/-/11600041001 | 0.027828
1078741 | Tender Text en | Product URL DE | 15 | 25 | 0.00000516767 | REHAU Compression sleeve RAUTITAN PX 20 | 4007360361211 | 11600021001 | 1949 | https://oxomi.com/p/3000126/datasheet/-/11600021001 | 0.011
1078743 | Tender Text en | Product URL DE | 15 | 25 | 0.00000516767 | REHAU Compression sleeve RAUTITAN PX 20 | 4007360361211 | 11600021001 | 1949 | https://oxomi.com/p/3000126/datasheet/-/11600021001 | 0.011
1078745 | Tender Text en | Product URL DE | 20 | 27.2 | 0.0000087028 | REHAU Compression sleeve RAUTITAN PX 25 | 4007360361228 | 11600031001 | 1950 | https://oxomi.com/p/3000126/datasheet/-/11600031001 | 0.015828
1078747 | Tender Text en | Product URL DE | 12 | 23.7 | 0.00000312848 | REHAU Compression sleeve RAUTITAN PX 16 | 4007360361204 | 11600011001 | 1947 | https://oxomi.com/p/3000126/datasheet/-/11600011001 | 0.0076
1078749 | Tender Text en | Product URL DE | 20 | 27.2 | 0.0000087028 | REHAU Compression sleeve RAUTITAN PX 25 | 4007360361228 | 11600031001 | 1950 | https://oxomi.com/p/3000126/datasheet/-/11600031001 | 0.015828
1078751 | Tender Text en | Product URL DE | 12 | 23.7 | 0.00000312848 | REHAU Compression sleeve RAUTITAN PX 16 | 4007360361204 | 11600011001 | 1947 | https://oxomi.com/p/3000126/datasheet/-/11600011001 | 0.0076
1078753 | Tender Text en | Product URL DE | 15 | 25 | 0.00000516767 | REHAU Compression sleeve RAUTITAN PX 20 | 4007360361211 | 11600021001 | 1949 | https://oxomi.com/p/3000126/datasheet/-/11600021001 | 0.011
1078755 | Tender Text en | Product URL DE | 25 | 34 | 0.0000174355 | REHAU Compression sleeve RAUTITAN PX 32 | 4007360361235 | 11600041001 | 1951 | https://oxomi.com/p/3000126/datasheet/-/11600041001 | 0.027828
1078757 | Tender Text en | Product URL DE | 15 | 25 | 0.00000516767 | REHAU Compression sleeve RAUTITAN PX 20 | 4007360361211 | 11600021001 | 1949 | https://oxomi.com/p/3000126/datasheet/-/11600021001 | 0.011
1078759 | Tender Text en | Product URL DE | 20 | 27.2 | 0.0000087028 | REHAU Compression sleeve RAUTITAN PX 25 | 4007360361228 | 11600031001 | 1950 | https://oxomi.com/p/3000126/datasheet/-/11600031001 | 0.015828
1078761 | Tender Text en | Product URL DE | 20 | 27.2 | 0.0000087028 | REHAU Compression sleeve RAUTITAN PX 25 | 4007360361228 | 11600031001 | 1950 | https://oxomi.com/p/3000126/datasheet/-/11600031001 | 0.015828
1078763 | Tender Text en | Product URL DE | 15 | 25 | 0.00000516767 | REHAU Compression sleeve RAUTITAN PX 20 | 4007360361211 | 11600021001 | 1949 | https://oxomi.com/p/3000126/datasheet/-/11600021001 | 0.011
1078765 | Tender Text en | Product URL DE | 12 | 23.7 | 0.00000312848 | REHAU Compression sleeve RAUTITAN PX 16 | 4007360361204 | 11600011001 | 1947 | https://oxomi.com/p/3000126/datasheet/-/11600011001 | 0.0076
1078767 | Tender Text en | Product URL DE | 25 | 34 | 0.0000174355 | REHAU Compression sleeve RAUTITAN PX 32 | 4007360361235 | 11600041001 | 1951 | https://oxomi.com/p/3000126/datasheet/-/11600041001 | 0.027828
1078769 | Tender Text en | Product URL DE | 20 | 27.2 | 0.0000087028 | REHAU Compression sleeve RAUTITAN PX 25 | 4007360361228 | 11600031001 | 1950 | https://oxomi.com/p/3000126/datasheet/-/11600031001 | 0.015828
1078771 | Tender Text en | Product URL DE | 15 | 25 | 0.00000516767 | REHAU Compression sleeve RAUTITAN PX 20 | 4007360361211 | 11600021001 | 1949 | https://oxomi.com/p/3000126/datasheet/-/11600021001 | 0.011
1078773 | Tender Text en | Product URL DE | 40 | 45 | 0.0000353695 | REHAU Compr. sleeve RAUTITAN PX stabil 50 | 4062178755416 | 11602061001 | 1954 | https://oxomi.com/p/3000126/datasheet/-/11602061001 | 0.0673
1078775 | Tender Text en | Product URL DE | 40 | 45 | 0.0000353695 | REHAU Compr. sleeve RAUTITAN PX stabil 50 | 4062178755416 | 11602061001 | 1954 | https://oxomi.com/p/3000126/datasheet/-/11602061001 | 0.0673
1078777 | Tender Text en | Product URL DE | 50 | 53 | 0.0000702282 | REHAU Compr. sleeve RAUTITAN PX stabil 63 | 4062178755423 | 11602071001 | 1955 | https://oxomi.com/p/3000126/datasheet/-/11602071001 | 0.1106
1078779 | Tender Text en | Product URL DE | 50 | 53 | 0.0000702282 | REHAU Compr. sleeve RAUTITAN PX stabil 63 | 4062178755423 | 11602071001 | 1955 | https://oxomi.com/p/3000126/datasheet/-/11602071001 | 0.1106
1078781 | Tender Text en | Product URL DE | 40 | 45 | 0.0000353695 | REHAU Compr. sleeve RAUTITAN PX stabil 50 | 4062178755416 | 11602061001 | 1954 | https://oxomi.com/p/3000126/datasheet/-/11602061001 | 0.0673
1078783 | Tender Text en | Product URL DE | 32 | 37.8 | 0.0000303041 | REHAU Compression sleeve RAUTITAN PX 40 | 4007360361242 | 11600051001 | 1952 | https://oxomi.com/p/3000126/datasheet/-/11600051001 | 0.03861
1078785 | Tender Text en | Product URL DE | 50 | 53 | 0.0000702282 | REHAU Compr. sleeve RAUTITAN PX stabil 63 | 4062178755423 | 11602071001 | 1955 | https://oxomi.com/p/3000126/datasheet/-/11602071001 | 0.1106
1078787 | Tender Text en | Product URL DE | 40 | 45 | 0.0000353695 | REHAU Compr. sleeve RAUTITAN PX stabil 50 | 4062178755416 | 11602061001 | 1954 | https://oxomi.com/p/3000126/datasheet/-/11602061001 | 0.0673
1078789 | Tender Text en | Product URL DE | 40 | 45 | 0.0000353695 | REHAU Compr. sleeve RAUTITAN PX stabil 50 | 4062178755416 | 11602061001 | 1954 | https://oxomi.com/p/3000126/datasheet/-/11602061001 | 0.0673
1078791 | Tender Text en | Product URL DE | 25 | 34 | 0.0000174355 | REHAU Compression sleeve RAUTITAN PX 32 | 4007360361235 | 11600041001 | 1951 | https://oxomi.com/p/3000126/datasheet/-/11600041001 | 0.027828
1078793 | Tender Text en | Product URL DE | 50 | 53 | 0.0000702282 | REHAU Compr. sleeve RAUTITAN PX stabil 63 | 4062178755423 | 11602071001 | 1955 | https://oxomi.com/p/3000126/datasheet/-/11602071001 | 0.1106
1078795 | Tender Text en | Product URL DE | 32 | 37.8 | 0.0000303041 | REHAU Compression sleeve RAUTITAN PX 40 | 4007360361242 | 11600051001 | 1952 | https://oxomi.com/p/3000126/datasheet/-/11600051001 | 0.03861
1078797 | Tender Text en | Product URL DE | 40 | 45 | 0.0000353695 | REHAU Compr. sleeve RAUTITAN PX stabil 50 | 4062178755416 | 11602061001 | 1954 | https://oxomi.com/p/3000126/datasheet/-/11602061001 | 0.0673
1078799 | Tender Text en | Product URL DE | 20 | 27.2 | 0.0000087028 | REHAU Compression sleeve RAUTITAN PX 25 | 4007360361228 | 11600031001 | 1950 | https://oxomi.com/p/3000126/datasheet/-/11600031001 | 0.015828
1078801 | Tender Text en | Product URL DE | 50 | 53 | 0.0000702282 | REHAU Compr. sleeve RAUTITAN PX stabil 63 | 4062178755423 | 11602071001 | 1955 | https://oxomi.com/p/3000126/datasheet/-/11602071001 | 0.1106
1078803 | Tender Text en | Product URL DE | 25 | 34 | 0.0000174355 | REHAU Compression sleeve RAUTITAN PX 32 | 4007360361235 | 11600041001 | 1951 | https://oxomi.com/p/3000126/datasheet/-/11600041001 | 0.027828
1078805 | Tender Text en | Product URL DE | 50 | 53 | 0.0000702282 | REHAU Compr. sleeve RAUTITAN PX stabil 63 | 4062178755423 | 11602071001 | 1955 | https://oxomi.com/p/3000126/datasheet/-/11602071001 | 0.1106
1078807 | Tender Text en | Product URL DE | 20 | 27.2 | 0.0000087028 | REHAU Compression sleeve RAUTITAN PX 25 | 4007360361228 | 11600031001 | 1950 | https://oxomi.com/p/3000126/datasheet/-/11600031001 | 0.015828
1078809 | Tender Text en | Product URL DE | 40 | 45 | 0.0000353695 | REHAU Compr. sleeve RAUTITAN PX stabil 50 | 4062178755416 | 11602061001 | 1954 | https://oxomi.com/p/3000126/datasheet/-/11602061001 | 0.0673
1078811 | Tender Text en | Product URL DE | 20 | 27.2 | 0.0000087028 | REHAU Compression sleeve RAUTITAN PX 25 | 4007360361228 | 11600031001 | 1950 | https://oxomi.com/p/3000126/datasheet/-/11600031001 | 0.015828
1078813 | Tender Text en | Product URL DE | 40 | 45 | 0.0000353695 | REHAU Compr. sleeve RAUTITAN PX stabil 50 | 4062178755416 | 11602061001 | 1954 | https://oxomi.com/p/3000126/datasheet/-/11602061001 | 0.0673
1078815 | Tender Text en | Product URL DE | 50 | 53 | 0.0000702282 | REHAU Compr. sleeve RAUTITAN PX stabil 63 | 4062178755423 | 11602071001 | 1955 | https://oxomi.com/p/3000126/datasheet/-/11602071001 | 0.1106
1078817 | Tender Text en | Product URL DE | 40 | 45 | 0.0000353695 | REHAU Compr. sleeve RAUTITAN PX stabil 50 | 4062178755416 | 11602061001 | 1954 | https://oxomi.com/p/3000126/datasheet/-/11602061001 | 0.0673
1078819 | Tender Text en | Product URL DE | 50 | 53 | 0.0000702282 | REHAU Compr. sleeve RAUTITAN PX stabil 63 | 4062178755423 | 11602071001 | 1955 | https://oxomi.com/p/3000126/datasheet/-/11602071001 | 0.1106
1078821 | Tender Text en | Product URL DE | 40 | 45 | 0.0000353695 | REHAU Compr. sleeve RAUTITAN PX stabil 50 | 4062178755416 | 11602061001 | 1954 | https://oxomi.com/p/3000126/datasheet/-/11602061001 | 0.0673
1078823 | Tender Text en | Product URL DE | 50 | 53 | 0.0000702282 | REHAU Compr. sleeve RAUTITAN PX stabil 63 | 4062178755423 | 11602071001 | 1955 | https://oxomi.com/p/3000126/datasheet/-/11602071001 | 0.1106
1078825 | Tender Text en | Product URL DE | 40 | 45 | 0.0000353695 | REHAU Compr. sleeve RAUTITAN PX stabil 50 | 4062178755416 | 11602061001 | 1954 | https://oxomi.com/p/3000126/datasheet/-/11602061001 | 0.0673
1078827 | Tender Text en | Product URL DE | 50 | 53 | 0.0000702282 | REHAU Compr. sleeve RAUTITAN PX stabil 63 | 4062178755423 | 11602071001 | 1955 | https://oxomi.com/p/3000126/datasheet/-/11602071001 | 0.1106
1078829 | Tender Text en | Product URL DE | 50 | 53 | 0.0000702282 | REHAU Compr. sleeve RAUTITAN PX stabil 63 | 4062178755423 | 11602071001 | 1955 | https://oxomi.com/p/3000126/datasheet/-/11602071001 | 0.1106
1078831 | Tender Text en | Product URL DE | 32 | 37.8 | 0.0000303041 | REHAU Compression sleeve RAUTITAN PX 40 | 4007360361242 | 11600051001 | 1952 | https://oxomi.com/p/3000126/datasheet/-/11600051001 | 0.03861
1078833 | Tender Text en | Product URL DE | 20 | 27.2 | 0.0000087028 | REHAU Compression sleeve RAUTITAN PX 25 | 4007360361228 | 11600031001 | 1950 | https://oxomi.com/p/3000126/datasheet/-/11600031001 | 0.015828
1078835 | Tender Text en | Product URL DE | 25 | 34 | 0.0000174355 | REHAU Compression sleeve RAUTITAN PX 32 | 4007360361235 | 11600041001 | 1951 | https://oxomi.com/p/3000126/datasheet/-/11600041001 | 0.027828
1078837 | Tender Text en | Product URL DE | 15 | 25 | 0.00000516767 | REHAU Compression sleeve RAUTITAN PX 20 | 4007360361211 | 11600021001 | 1949 | https://oxomi.com/p/3000126/datasheet/-/11600021001 | 0.011
1078843 | Tender Text en | Product URL DE | 20 | 27.2 | 0.0000087028 | REHAU Compression sleeve RAUTITAN PX 25 | 4007360361228 | 11600031001 | 1950 | https://oxomi.com/p/3000126/datasheet/-/11600031001 | 0.015828
1078845 | Tender Text en | Product URL DE | 25 | 34 | 0.0000174355 | REHAU Compression sleeve RAUTITAN PX 32 | 4007360361235 | 11600041001 | 1951 | https://oxomi.com/p/3000126/datasheet/-/11600041001 | 0.027828
1078851 | Tender Text en | Product URL DE | 25 | 34 | 0.0000174355 | REHAU Compression sleeve RAUTITAN PX 32 | 4007360361235 | 11600041001 | 1951 | https://oxomi.com/p/3000126/datasheet/-/11600041001 | 0.027828
1078867 | Tender Text en | Product URL DE | 20 | 27.2 | 0.0000087028 | REHAU Compression sleeve RAUTITAN PX 25 | 4007360361228 | 11600031001 | 1950 | https://oxomi.com/p/3000126/datasheet/-/11600031001 | 0.015828
1078869 | Tender Text en | Product URL DE | 25 | 34 | 0.0000174355 | REHAU Compression sleeve RAUTITAN PX 32 | 4007360361235 | 11600041001 | 1951 | https://oxomi.com/p/3000126/datasheet/-/11600041001 | 0.027828
1078871 | Tender Text en | Product URL DE | 20 | 27.2 | 0.0000087028 | REHAU Compression sleeve RAUTITAN PX 25 | 4007360361228 | 11600031001 | 1950 | https://oxomi.com/p/3000126/datasheet/-/11600031001 | 0.015828
1078873 | Tender Text en | Product URL DE | 25 | 34 | 0.0000174355 | REHAU Compression sleeve RAUTITAN PX 32 | 4007360361235 | 11600041001 | 1951 | https://oxomi.com/p/3000126/datasheet/-/11600041001 | 0.027828
1078875 | Tender Text en | Product URL DE | 15 | 25 | 0.00000516767 | REHAU Compression sleeve RAUTITAN PX 20 | 4007360361211 | 11600021001 | 1949 | https://oxomi.com/p/3000126/datasheet/-/11600021001 | 0.011
1078881 | Tender Text en | Product URL DE | 20 | 27.2 | 0.0000087028 | REHAU Compression sleeve RAUTITAN PX 25 | 4007360361228 | 11600031001 | 1950 | https://oxomi.com/p/3000126/datasheet/-/11600031001 | 0.015828
1078883 | Tender Text en | Product URL DE | 25 | 34 | 0.0000174355 | REHAU Compression sleeve RAUTITAN PX 32 | 4007360361235 | 11600041001 | 1951 | https://oxomi.com/p/3000126/datasheet/-/11600041001 | 0.027828
1078889 | Tender Text en | Product URL DE | 25 | 34 | 0.0000174355 | REHAU Compression sleeve RAUTITAN PX 32 | 4007360361235 | 11600041001 | 1951 | https://oxomi.com/p/3000126/datasheet/-/11600041001 | 0.027828
1078905 | Tender Text en | Product URL DE | 15 | 25 | 0.00000516767 | REHAU Compression sleeve RAUTITAN PX 20 | 4007360361211 | 11600021001 | 1949 | https://oxomi.com/p/3000126/datasheet/-/11600021001 | 0.011
1078907 | Tender Text en | Product URL DE | 20 | 27.2 | 0.0000087028 | REHAU Compression sleeve RAUTITAN PX 25 | 4007360361228 | 11600031001 | 1950 | https://oxomi.com/p/3000126/datasheet/-/11600031001 | 0.015828
1078909 | Tender Text en | Product URL DE | 20 | 27.2 | 0.0000087028 | REHAU Compression sleeve RAUTITAN PX 25 | 4007360361228 | 11600031001 | 1950 | https://oxomi.com/p/3000126/datasheet/-/11600031001 | 0.015828
1078911 | Tender Text en | Product URL DE | 25 | 34 | 0.0000174355 | REHAU Compression sleeve RAUTITAN PX 32 | 4007360361235 | 11600041001 | 1951 | https://oxomi.com/p/3000126/datasheet/-/11600041001 | 0.027828
1078913 | Tender Text en | Product URL DE | 15 | 25 | 0.00000516767 | REHAU Compression sleeve RAUTITAN PX 20 | 4007360361211 | 11600021001 | 1949 | https://oxomi.com/p/3000126/datasheet/-/11600021001 | 0.011
1078919 | Tender Text en | Product URL DE | 15 | 25 | 0.00000516767 | REHAU Compression sleeve RAUTITAN PX 20 | 4007360361211 | 11600021001 | 1949 | https://oxomi.com/p/3000126/datasheet/-/11600021001 | 0.011
1078921 | Tender Text en | Product URL DE | 20 | 27.2 | 0.0000087028 | REHAU Compression sleeve RAUTITAN PX 25 | 4007360361228 | 11600031001 | 1950 | https://oxomi.com/p/3000126/datasheet/-/11600031001 | 0.015828
1078923 | Tender Text en | Product URL DE | 32 | 37.8 | 0.0000303041 | REHAU Compression sleeve RAUTITAN PX 40 | 4007360361242 | 11600051001 | 1952 | https://oxomi.com/p/3000126/datasheet/-/11600051001 | 0.03861
1078927 | Tender Text en | Product URL DE | 15 | 25 | 0.00000516767 | REHAU Compression sleeve RAUTITAN PX 20 | 4007360361211 | 11600021001 | 1949 | https://oxomi.com/p/3000126/datasheet/-/11600021001 | 0.011
1078929 | Tender Text en | Product URL DE | 25 | 34 | 0.0000174355 | REHAU Compression sleeve RAUTITAN PX 32 | 4007360361235 | 11600041001 | 1951 | https://oxomi.com/p/3000126/datasheet/-/11600041001 | 0.027828
1078931 | Tender Text en | Product URL DE | 32 | 37.8 | 0.0000303041 | REHAU Compression sleeve RAUTITAN PX 40 | 4007360361242 | 11600051001 | 1952 | https://oxomi.com/p/3000126/datasheet/-/11600051001 | 0.03861
1078933 | Tender Text en | Product URL DE | 20 | 27.2 | 0.0000087028 | REHAU Compression sleeve RAUTITAN PX 25 | 4007360361228 | 11600031001 | 1950 | https://oxomi.com/p/3000126/datasheet/-/11600031001 | 0.015828
1078935 | Tender Text en | Product URL DE | 25 | 34 | 0.0000174355 | REHAU Compression sleeve RAUTITAN PX 32 | 4007360361235 | 11600041001 | 1951 | https://oxomi.com/p/3000126/datasheet/-/11600041001 | 0.027828
1078937 | Tender Text en | Product URL DE | 15 | 25 | 0.00000516767 | REHAU Compression sleeve RAUTITAN PX 20 | 4007360361211 | 11600021001 | 1949 | https://oxomi.com/p/3000126/datasheet/-/11600021001 | 0.011
1078939 | Tender Text en | Product URL DE | 20 | 27.2 | 0.0000087028 | REHAU Compression sleeve RAUTITAN PX 25 | 4007360361228 | 11600031001 | 1950 | https://oxomi.com/p/3000126/datasheet/-/11600031001 | 0.015828
1078941 | Tender Text en | Product URL DE | 15 | 25 | 0.00000516767 | REHAU Compression sleeve RAUTITAN PX 20 | 4007360361211 | 11600021001 | 1949 | https://oxomi.com/p/3000126/datasheet/-/11600021001 | 0.011
1078943 | Tender Text en | Product URL DE | 15 | 25 | 0.00000516767 | REHAU Compression sleeve RAUTITAN PX 20 | 4007360361211 | 11600021001 | 1949 | https://oxomi.com/p/3000126/datasheet/-/11600021001 | 0.011
1078945 | Tender Text en | Product URL DE | 20 | 27.2 | 0.0000087028 | REHAU Compression sleeve RAUTITAN PX 25 | 4007360361228 | 11600031001 | 1950 | https://oxomi.com/p/3000126/datasheet/-/11600031001 | 0.015828
1078947 | Tender Text en | Product URL DE | 32 | 37.8 | 0.0000303041 | REHAU Compression sleeve RAUTITAN PX 40 | 4007360361242 | 11600051001 | 1952 | https://oxomi.com/p/3000126/datasheet/-/11600051001 | 0.03861
1078949 | Tender Text en | Product URL DE | 25 | 34 | 0.0000174355 | REHAU Compression sleeve RAUTITAN PX 32 | 4007360361235 | 11600041001 | 1951 | https://oxomi.com/p/3000126/datasheet/-/11600041001 | 0.027828
1078951 | Tender Text en | Product URL DE | 25 | 34 | 0.0000174355 | REHAU Compression sleeve RAUTITAN PX 32 | 4007360361235 | 11600041001 | 1951 | https://oxomi.com/p/3000126/datasheet/-/11600041001 | 0.027828
1078953 | Tender Text en | Product URL DE | 20 | 27.2 | 0.0000087028 | REHAU Compression sleeve RAUTITAN PX 25 | 4007360361228 | 11600031001 | 1950 | https://oxomi.com/p/3000126/datasheet/-/11600031001 | 0.015828
1078955 | Tender Text en | Product URL DE | 20 | 27.2 | 0.0000087028 | REHAU Compression sleeve RAUTITAN PX 25 | 4007360361228 | 11600031001 | 1950 | https://oxomi.com/p/3000126/datasheet/-/11600031001 | 0.015828
1078957 | Tender Text en | Product URL DE | 15 | 25 | 0.00000516767 | REHAU Compression sleeve RAUTITAN PX 20 | 4007360361211 | 11600021001 | 1949 | https://oxomi.com/p/3000126/datasheet/-/11600021001 | 0.011
1078959 | Tender Text en | Product URL DE | 15 | 25 | 0.00000516767 | REHAU Compression sleeve RAUTITAN PX 20 | 4007360361211 | 11600021001 | 1949 | https://oxomi.com/p/3000126/datasheet/-/11600021001 | 0.011
1078961 | Tender Text en | Product URL DE | 12 | 23.7 | 0.00000312848 | REHAU Compression sleeve RAUTITAN PX 16 | 4007360361204 | 11600011001 | 1947 | https://oxomi.com/p/3000126/datasheet/-/11600011001 | 0.0076
1078969 | Tender Text en | Product URL DE | 32 | 37.8 | 0.0000303041 | REHAU Compression sleeve RAUTITAN PX 40 | 4007360361242 | 11600051001 | 1952 | https://oxomi.com/p/3000126/datasheet/-/11600051001 | 0.03861
1078975 | Tender Text en | Product URL DE | 32 | 37.8 | 0.0000303041 | REHAU Compression sleeve RAUTITAN PX 40 | 4007360361242 | 11600051001 | 1952 | https://oxomi.com/p/3000126/datasheet/-/11600051001 | 0.03861
1078977 | Tender Text en | Product URL DE | 25 | 34 | 0.0000174355 | REHAU Compression sleeve RAUTITAN PX 32 | 4007360361235 | 11600041001 | 1951 | https://oxomi.com/p/3000126/datasheet/-/11600041001 | 0.027828
1078979 | Tender Text en | Product URL DE | 25 | 34 | 0.0000174355 | REHAU Compression sleeve RAUTITAN PX 32 | 4007360361235 | 11600041001 | 1951 | https://oxomi.com/p/3000126/datasheet/-/11600041001 | 0.027828
1078981 | Tender Text en | Product URL DE | 20 | 27.2 | 0.0000087028 | REHAU Compression sleeve RAUTITAN PX 25 | 4007360361228 | 11600031001 | 1950 | https://oxomi.com/p/3000126/datasheet/-/11600031001 | 0.015828
1078983 | Tender Text en | Product URL DE | 20 | 27.2 | 0.0000087028 | REHAU Compression sleeve RAUTITAN PX 25 | 4007360361228 | 11600031001 | 1950 | https://oxomi.com/p/3000126/datasheet/-/11600031001 | 0.015828
1078985 | Tender Text en | Product URL DE | 15 | 25 | 0.00000516767 | REHAU Compression sleeve RAUTITAN PX 20 | 4007360361211 | 11600021001 | 1949 | https://oxomi.com/p/3000126/datasheet/-/11600021001 | 0.011
1078987 | Tender Text en | Product URL DE | 15 | 25 | 0.00000516767 | REHAU Compression sleeve RAUTITAN PX 20 | 4007360361211 | 11600021001 | 1949 | https://oxomi.com/p/3000126/datasheet/-/11600021001 | 0.011
1078989 | Tender Text en | Product URL DE | 12 | 23.7 | 0.00000312848 | REHAU Compression sleeve RAUTITAN PX 16 | 4007360361204 | 11600011001 | 1947 | https://oxomi.com/p/3000126/datasheet/-/11600011001 | 0.0076
1078991 | Tender Text en | Product URL DE | 20 | 27.2 | 0.0000087028 | REHAU Compression sleeve RAUTITAN PX 25 | 4007360361228 | 11600031001 | 1950 | https://oxomi.com/p/3000126/datasheet/-/11600031001 | 0.015828
1078993 | Tender Text en | Product URL DE | 12 | 23.7 | 0.00000312848 | REHAU Compression sleeve RAUTITAN PX 16 | 4007360361204 | 11600011001 | 1947 | https://oxomi.com/p/3000126/datasheet/-/11600011001 | 0.0076
1078995 | Tender Text en | Product URL DE | 40 | 45 | 0.0000353695 | REHAU Compr. sleeve RAUTITAN PX stabil 50 | 4062178755416 | 11602061001 | 1954 | https://oxomi.com/p/3000126/datasheet/-/11602061001 | 0.0673
1078997 | Tender Text en | Product URL DE | 32 | 37.8 | 0.0000303041 | REHAU Compression sleeve RAUTITAN PX 40 | 4007360361242 | 11600051001 | 1952 | https://oxomi.com/p/3000126/datasheet/-/11600051001 | 0.03861
1078999 | Tender Text en | Product URL DE | 50 | 53 | 0.0000702282 | REHAU Compr. sleeve RAUTITAN PX stabil 63 | 4062178755423 | 11602071001 | 1955 | https://oxomi.com/p/3000126/datasheet/-/11602071001 | 0.1106
1079001 | Tender Text en | Product URL DE | 40 | 45 | 0.0000353695 | REHAU Compr. sleeve RAUTITAN PX stabil 50 | 4062178755416 | 11602061001 | 1954 | https://oxomi.com/p/3000126/datasheet/-/11602061001 | 0.0673
1079003 | Tender Text en | Product URL DE | 40 | 45 | 0.0000353695 | REHAU Compr. sleeve RAUTITAN PX stabil 50 | 4062178755416 | 11602061001 | 1954 | https://oxomi.com/p/3000126/datasheet/-/11602061001 | 0.0673
1079005 | Tender Text en | Product URL DE | 25 | 34 | 0.0000174355 | REHAU Compression sleeve RAUTITAN PX 32 | 4007360361235 | 11600041001 | 1951 | https://oxomi.com/p/3000126/datasheet/-/11600041001 | 0.027828
1079007 | Tender Text en | Product URL DE | 32 | 37.8 | 0.0000303041 | REHAU Compression sleeve RAUTITAN PX 40 | 4007360361242 | 11600051001 | 1952 | https://oxomi.com/p/3000126/datasheet/-/11600051001 | 0.03861
1079009 | Tender Text en | Product URL DE | 20 | 27.2 | 0.0000087028 | REHAU Compression sleeve RAUTITAN PX 25 | 4007360361228 | 11600031001 | 1950 | https://oxomi.com/p/3000126/datasheet/-/11600031001 | 0.015828
1079013 | Tender Text en | Product URL DE | 32 | 37.8 | 0.0000303041 | REHAU Compression sleeve RAUTITAN PX 40 | 4007360361242 | 11600051001 | 1952 | https://oxomi.com/p/3000126/datasheet/-/11600051001 | 0.03861
1079019 | Tender Text en | Product URL DE | 25 | 34 | 0.0000174355 | REHAU Compression sleeve RAUTITAN PX 32 | 4007360361235 | 11600041001 | 1951 | https://oxomi.com/p/3000126/datasheet/-/11600041001 | 0.027828
1079021 | Tender Text en | Product URL DE | 20 | 27.2 | 0.0000087028 | REHAU Compression sleeve RAUTITAN PX 25 | 4007360361228 | 11600031001 | 1950 | https://oxomi.com/p/3000126/datasheet/-/11600031001 | 0.015828
1079023 | Tender Text en | Product URL DE | 20 | 27.2 | 0.0000087028 | REHAU Compression sleeve RAUTITAN PX 25 | 4007360361228 | 11600031001 | 1950 | https://oxomi.com/p/3000126/datasheet/-/11600031001 | 0.015828
1079025 | Tender Text en | Product URL DE | 15 | 25 | 0.00000516767 | REHAU Compression sleeve RAUTITAN PX 20 | 4007360361211 | 11600021001 | 1949 | https://oxomi.com/p/3000126/datasheet/-/11600021001 | 0.011
1079029 | Tender Text en | Product URL DE | 25 | 34 | 0.0000174355 | REHAU Compression sleeve RAUTITAN PX 32 | 4007360361235 | 11600041001 | 1951 | https://oxomi.com/p/3000126/datasheet/-/11600041001 | 0.027828
1079031 | Tender Text en | Product URL DE | 12 | 23.7 | 0.00000312848 | REHAU Compression sleeve RAUTITAN PX 16 | 4007360361204 | 11600011001 | 1947 | https://oxomi.com/p/3000126/datasheet/-/11600011001 | 0.0076
1079033 | Tender Text en | Product URL DE | 12 | 23.7 | 0.00000312848 | REHAU Compression sleeve RAUTITAN PX 16 | 4007360361204 | 11600011001 | 1947 | https://oxomi.com/p/3000126/datasheet/-/11600011001 | 0.0076
1079035 | Tender Text en | Product URL DE | 15 | 25 | 0.00000516767 | REHAU Compression sleeve RAUTITAN PX 20 | 4007360361211 | 11600021001 | 1949 | https://oxomi.com/p/3000126/datasheet/-/11600021001 | 0.011
1079037 | Tender Text en | Product URL DE | 15 | 25 | 0.00000516767 | REHAU Compression sleeve RAUTITAN PX 20 | 4007360361211 | 11600021001 | 1949 | https://oxomi.com/p/3000126/datasheet/-/11600021001 | 0.011
1079039 | Tender Text en | Product URL DE | 20 | 27.2 | 0.0000087028 | REHAU Compression sleeve RAUTITAN PX 25 | 4007360361228 | 11600031001 | 1950 | https://oxomi.com/p/3000126/datasheet/-/11600031001 | 0.015828
1079041 | Tender Text en | Product URL DE | 20 | 27.2 | 0.0000087028 | REHAU Compression sleeve RAUTITAN PX 25 | 4007360361228 | 11600031001 | 1950 | https://oxomi.com/p/3000126/datasheet/-/11600031001 | 0.015828
1079043 | Tender Text en | Product URL DE | 25 | 34 | 0.0000174355 | REHAU Compression sleeve RAUTITAN PX 32 | 4007360361235 | 11600041001 | 1951 | https://oxomi.com/p/3000126/datasheet/-/11600041001 | 0.027828
1079045 | Tender Text en | Product URL DE | 25 | 34 | 0.0000174355 | REHAU Compression sleeve RAUTITAN PX 32 | 4007360361235 | 11600041001 | 1951 | https://oxomi.com/p/3000126/datasheet/-/11600041001 | 0.027828
1079047 | Tender Text en | Product URL DE | 32 | 37.8 | 0.0000303041 | REHAU Compression sleeve RAUTITAN PX 40 | 4007360361242 | 11600051001 | 1952 | https://oxomi.com/p/3000126/datasheet/-/11600051001 | 0.03861
1079049 | Tender Text en | Product URL DE | 32 | 37.8 | 0.0000303041 | REHAU Compression sleeve RAUTITAN PX 40 | 4007360361242 | 11600051001 | 1952 | https://oxomi.com/p/3000126/datasheet/-/11600051001 | 0.03861
1081596 | Tender Text en | Product URL DE | 12 | 23.7 | 0.00000312848 | REHAU Compression sleeve RAUTITAN PX 16 | 4007360361204 | 11600011001 | 1947 | https://oxomi.com/p/3000126/datasheet/-/11600011001 | 0.0076
1081598 | Tender Text en | Product URL DE | 12 | 23.7 | 0.00000312848 | REHAU Compression sleeve RAUTITAN PX 16 | 4007360361204 | 11600011001 | 1947 | https://oxomi.com/p/3000126/datasheet/-/11600011001 | 0.0076
1081602 | Tender Text en | Product URL DE | 15 | 25 | 0.00000516767 | REHAU Compression sleeve RAUTITAN PX 20 | 4007360361211 | 11600021001 | 1949 | https://oxomi.com/p/3000126/datasheet/-/11600021001 | 0.011
1081604 | Tender Text en | Product URL DE | 15 | 25 | 0.00000516767 | REHAU Compression sleeve RAUTITAN PX 20 | 4007360361211 | 11600021001 | 1949 | https://oxomi.com/p/3000126/datasheet/-/11600021001 | 0.011
1081608 | Tender Text en | Product URL DE | 20 | 27.2 | 0.0000087028 | REHAU Compression sleeve RAUTITAN PX 25 | 4007360361228 | 11600031001 | 1950 | https://oxomi.com/p/3000126/datasheet/-/11600031001 | 0.015828
1081610 | Tender Text en | Product URL DE | 20 | 27.2 | 0.0000087028 | REHAU Compression sleeve RAUTITAN PX 25 | 4007360361228 | 11600031001 | 1950 | https://oxomi.com/p/3000126/datasheet/-/11600031001 | 0.015828
1081614 | Tender Text en | Product URL DE | 25 | 34 | 0.0000174355 | REHAU Compression sleeve RAUTITAN PX 32 | 4007360361235 | 11600041001 | 1951 | https://oxomi.com/p/3000126/datasheet/-/11600041001 | 0.027828
1081616 | Tender Text en | Product URL DE | 25 | 34 | 0.0000174355 | REHAU Compression sleeve RAUTITAN PX 32 | 4007360361235 | 11600041001 | 1951 | https://oxomi.com/p/3000126/datasheet/-/11600041001 | 0.027828
1081618 | Tender Text en | Product URL DE | 32 | 37.8 | 0.0000303041 | REHAU Compression sleeve RAUTITAN PX 40 | 4007360361242 | 11600051001 | 1952 | https://oxomi.com/p/3000126/datasheet/-/11600051001 | 0.03861
1081620 | Tender Text en | Product URL DE | 32 | 37.8 | 0.0000303041 | REHAU Compression sleeve RAUTITAN PX 40 | 4007360361242 | 11600051001 | 1952 | https://oxomi.com/p/3000126/datasheet/-/11600051001 | 0.03861
1084065 | Tender Text en | Product URL DE | 40 | 45 | 0.0000353695 | REHAU Compr. sleeve RAUTITAN PX stabil 50 | 4062178755416 | 11602061001 | 1954 | https://oxomi.com/p/3000126/datasheet/-/11602061001 | 0.0673
1084067 | Tender Text en | Product URL DE | 40 | 45 | 0.0000353695 | REHAU Compr. sleeve RAUTITAN PX stabil 50 | 4062178755416 | 11602061001 | 1954 | https://oxomi.com/p/3000126/datasheet/-/11602061001 | 0.0673
1084069 | Tender Text en | Product URL DE | 50 | 53 | 0.0000702282 | REHAU Compr. sleeve RAUTITAN PX stabil 63 | 4062178755423 | 11602071001 | 1955 | https://oxomi.com/p/3000126/datasheet/-/11602071001 | 0.1106
1084071 | Tender Text en | Product URL DE | 50 | 53 | 0.0000702282 | REHAU Compr. sleeve RAUTITAN PX stabil 63 | 4062178755423 | 11602071001 | 1955 | https://oxomi.com/p/3000126/datasheet/-/11602071001 | 0.1106
1086519 | Tender Text en | Product URL DE | 15 | 25 | 0.00000516767 | REHAU Compression sleeve RAUTITAN PX 20 | 4007360361211 | 11600021001 | 1949 | https://oxomi.com/p/3000126/datasheet/-/11600021001 | 0.011
1086521 | Tender Text en | Product URL DE | 15 | 25 | 0.00000516767 | REHAU Compression sleeve RAUTITAN PX 20 | 4007360361211 | 11600021001 | 1949 | https://oxomi.com/p/3000126/datasheet/-/11600021001 | 0.011
1086525 | Tender Text en | Product URL DE | 20 | 27.2 | 0.0000087028 | REHAU Compression sleeve RAUTITAN PX 25 | 4007360361228 | 11600031001 | 1950 | https://oxomi.com/p/3000126/datasheet/-/11600031001 | 0.015828
1086527 | Tender Text en | Product URL DE | 20 | 27.2 | 0.0000087028 | REHAU Compression sleeve RAUTITAN PX 25 | 4007360361228 | 11600031001 | 1950 | https://oxomi.com/p/3000126/datasheet/-/11600031001 | 0.015828
1086531 | Tender Text en | Product URL DE | 25 | 34 | 0.0000174355 | REHAU Compression sleeve RAUTITAN PX 32 | 4007360361235 | 11600041001 | 1951 | https://oxomi.com/p/3000126/datasheet/-/11600041001 | 0.027828
1086533 | Tender Text en | Product URL DE | 25 | 34 | 0.0000174355 | REHAU Compression sleeve RAUTITAN PX 32 | 4007360361235 | 11600041001 | 1951 | https://oxomi.com/p/3000126/datasheet/-/11600041001 | 0.027828
1441483 | Tender Text en | Product URL DE | 15 | 25 | 0.00000516767 | REHAU Compression sleeve RAUTITAN PX 20 | 4007360361211 | 11600021001 | 1949 | https://oxomi.com/p/3000126/datasheet/-/11600021001 | 0.011
1441484 | Tender Text en | Product URL DE | 15 | 25 | 0.00000516767 | REHAU Compression sleeve RAUTITAN PX 20 | 4007360361211 | 11600021001 | 1949 | https://oxomi.com/p/3000126/datasheet/-/11600021001 | 0.011
1441968 | Tender Text en | Product URL DE | 12 | 23.7 | 0.00000312848 | REHAU Compression sleeve RAUTITAN PX 16 | 4007360361204 | 11600011001 | 1947 | https://oxomi.com/p/3000126/datasheet/-/11600011001 | 0.0076
1442035 | Tender Text en | Product URL DE | 15 | 25 | 0.00000516767 | REHAU Compression sleeve RAUTITAN PX 20 | 4007360361211 | 11600021001 | 1949 | https://oxomi.com/p/3000126/datasheet/-/11600021001 | 0.011
1442378 | Tender Text en | Product URL DE | 12 | 23.7 | 0.00000312848 | REHAU Compression sleeve RAUTITAN PX 16 | 4007360361204 | 11600011001 | 1947 | https://oxomi.com/p/3000126/datasheet/-/11600011001 | 0.0076
1442379 | Tender Text en | Product URL DE | 12 | 23.7 | 0.00000312848 | REHAU Compression sleeve RAUTITAN PX 16 | 4007360361204 | 11600011001 | 1947 | https://oxomi.com/p/3000126/datasheet/-/11600011001 | 0.0076
1442401 | Tender Text en | Product URL DE | 15 | 25 | 0.00000516767 | REHAU Compression sleeve RAUTITAN PX 20 | 4007360361211 | 11600021001 | 1949 | https://oxomi.com/p/3000126/datasheet/-/11600021001 | 0.011
1442405 | Tender Text en | Product URL DE | 12 | 23.7 | 0.00000312848 | REHAU Compression sleeve RAUTITAN PX 16 | 4007360361204 | 11600011001 | 1947 | https://oxomi.com/p/3000126/datasheet/-/11600011001 | 0.0076
1443067 | Tender Text en | Product URL DE | 40 | 45 | 0.0000353695 | REHAU Compr. sleeve RAUTITAN PX stabil 50 | 4062178755416 | 11602061001 | 1954 | https://oxomi.com/p/3000126/datasheet/-/11602061001 | 0.0673
1443071 | Tender Text en | Product URL DE | 50 | 53 | 0.0000702282 | REHAU Compr. sleeve RAUTITAN PX stabil 63 | 4062178755423 | 11602071001 | 1955 | https://oxomi.com/p/3000126/datasheet/-/11602071001 | 0.1106
1443668 | Tender Text en | Product URL DE | 12 | 23.7 | 0.00000312848 | REHAU Compression sleeve RAUTITAN PX 16 | 4007360361204 | 11600011001 | 1947 | https://oxomi.com/p/3000126/datasheet/-/11600011001 | 0.0076
1443732 | Tender Text en | Product URL DE | 15 | 25 | 0.00000516767 | REHAU Compression sleeve RAUTITAN PX 20 | 4007360361211 | 11600021001 | 1949 | https://oxomi.com/p/3000126/datasheet/-/11600021001 | 0.011
1443736 | Tender Text en | Product URL DE | 15 | 25 | 0.00000516767 | REHAU Compression sleeve RAUTITAN PX 20 | 4007360361211 | 11600021001 | 1949 | https://oxomi.com/p/3000126/datasheet/-/11600021001 | 0.011
1443740 | Tender Text en | Product URL DE | 20 | 27.2 | 0.0000087028 | REHAU Compression sleeve RAUTITAN PX 25 | 4007360361228 | 11600031001 | 1950 | https://oxomi.com/p/3000126/datasheet/-/11600031001 | 0.015828
1443744 | Tender Text en | Product URL DE | 20 | 27.2 | 0.0000087028 | REHAU Compression sleeve RAUTITAN PX 25 | 4007360361228 | 11600031001 | 1950 | https://oxomi.com/p/3000126/datasheet/-/11600031001 | 0.015828
1443748 | Tender Text en | Product URL DE | 25 | 34 | 0.0000174355 | REHAU Compression sleeve RAUTITAN PX 32 | 4007360361235 | 11600041001 | 1951 | https://oxomi.com/p/3000126/datasheet/-/11600041001 | 0.027828
1443752 | Tender Text en | Product URL DE | 25 | 34 | 0.0000174355 | REHAU Compression sleeve RAUTITAN PX 32 | 4007360361235 | 11600041001 | 1951 | https://oxomi.com/p/3000126/datasheet/-/11600041001 | 0.027828
1443756 | Tender Text en | Product URL DE | 32 | 37.8 | 0.0000303041 | REHAU Compression sleeve RAUTITAN PX 40 | 4007360361242 | 11600051001 | 1952 | https://oxomi.com/p/3000126/datasheet/-/11600051001 | 0.03861
1443804 | Tender Text en | Product URL DE | 20 | 27.2 | 0.0000087028 | REHAU Compression sleeve RAUTITAN PX 25 | 4007360361228 | 11600031001 | 1950 | https://oxomi.com/p/3000126/datasheet/-/11600031001 | 0.015828
1444899 | Tender Text en | Product URL DE | 12 | 23.7 | 0.00000312848 | REHAU Compression sleeve RAUTITAN PX 16 | 4007360361204 | 11600011001 | 1947 | https://oxomi.com/p/3000126/datasheet/-/11600011001 | 0.0076
1444903 | Tender Text en | Product URL DE | 25 | 34 | 0.0000174355 | REHAU Compression sleeve RAUTITAN PX 32 | 4007360361235 | 11600041001 | 1951 | https://oxomi.com/p/3000126/datasheet/-/11600041001 | 0.027828
1444904 | Tender Text en | Product URL DE | 20 | 27.2 | 0.0000087028 | REHAU Compression sleeve RAUTITAN PX 25 | 4007360361228 | 11600031001 | 1950 | https://oxomi.com/p/3000126/datasheet/-/11600031001 | 0.015828
1444905 | Tender Text en | Product URL DE | 12 | 23.7 | 0.00000312848 | REHAU Compression sleeve RAUTITAN PX 16 | 4007360361204 | 11600011001 | 1947 | https://oxomi.com/p/3000126/datasheet/-/11600011001 | 0.0076
1444913 | Tender Text en | Product URL DE | 12 | 23.7 | 0.00000312848 | REHAU Compression sleeve RAUTITAN PX 16 | 4007360361204 | 11600011001 | 1947 | https://oxomi.com/p/3000126/datasheet/-/11600011001 | 0.0076
1444914 | Tender Text en | Product URL DE | 12 | 23.7 | 0.00000312848 | REHAU Compression sleeve RAUTITAN PX 16 | 4007360361204 | 11600011001 | 1947 | https://oxomi.com/p/3000126/datasheet/-/11600011001 | 0.0076
1444919 | Tender Text en | Product URL DE | 12 | 23.7 | 0.00000312848 | REHAU Compression sleeve RAUTITAN PX 16 | 4007360361204 | 11600011001 | 1947 | https://oxomi.com/p/3000126/datasheet/-/11600011001 | 0.0076
1444920 | Tender Text en | Product URL DE | 12 | 23.7 | 0.00000312848 | REHAU Compression sleeve RAUTITAN PX 16 | 4007360361204 | 11600011001 | 1947 | https://oxomi.com/p/3000126/datasheet/-/11600011001 | 0.0076
1444921 | Tender Text en | Product URL DE | 12 | 23.7 | 0.00000312848 | REHAU Compression sleeve RAUTITAN PX 16 | 4007360361204 | 11600011001 | 1947 | https://oxomi.com/p/3000126/datasheet/-/11600011001 | 0.0076
1444927 | Tender Text en | Product URL DE | 12 | 23.7 | 0.00000312848 | REHAU Compression sleeve RAUTITAN PX 16 | 4007360361204 | 11600011001 | 1947 | https://oxomi.com/p/3000126/datasheet/-/11600011001 | 0.0076
1444931 | Tender Text en | Product URL DE | 12 | 23.7 | 0.00000312848 | REHAU Compression sleeve RAUTITAN PX 16 | 4007360361204 | 11600011001 | 1947 | https://oxomi.com/p/3000126/datasheet/-/11600011001 | 0.0076
1444941 | Tender Text en | Product URL DE | 20 | 27.2 | 0.0000087028 | REHAU Compression sleeve RAUTITAN PX 25 | 4007360361228 | 11600031001 | 1950 | https://oxomi.com/p/3000126/datasheet/-/11600031001 | 0.015828
1444942 | Tender Text en | Product URL DE | 20 | 27.2 | 0.0000087028 | REHAU Compression sleeve RAUTITAN PX 25 | 4007360361228 | 11600031001 | 1950 | https://oxomi.com/p/3000126/datasheet/-/11600031001 | 0.015828
1444947 | Tender Text en | Product URL DE | 15 | 25 | 0.00000516767 | REHAU Compression sleeve RAUTITAN PX 20 | 4007360361211 | 11600021001 | 1949 | https://oxomi.com/p/3000126/datasheet/-/11600021001 | 0.011
1444948 | Tender Text en | Product URL DE | 15 | 25 | 0.00000516767 | REHAU Compression sleeve RAUTITAN PX 20 | 4007360361211 | 11600021001 | 1949 | https://oxomi.com/p/3000126/datasheet/-/11600021001 | 0.011
1444953 | Tender Text en | Product URL DE | 12 | 23.7 | 0.00000312848 | REHAU Compression sleeve RAUTITAN PX 16 | 4007360361204 | 11600011001 | 1947 | https://oxomi.com/p/3000126/datasheet/-/11600011001 | 0.0076
1444954 | Tender Text en | Product URL DE | 12 | 23.7 | 0.00000312848 | REHAU Compression sleeve RAUTITAN PX 16 | 4007360361204 | 11600011001 | 1947 | https://oxomi.com/p/3000126/datasheet/-/11600011001 | 0.0076
1444959 | Tender Text en | Product URL DE | 12 | 23.7 | 0.00000312848 | REHAU Compression sleeve RAUTITAN PX 16 | 4007360361204 | 11600011001 | 1947 | https://oxomi.com/p/3000126/datasheet/-/11600011001 | 0.0076
1444964 | Tender Text en | Product URL DE | 15 | 25 | 0.00000516767 | REHAU Compression sleeve RAUTITAN PX 20 | 4007360361211 | 11600021001 | 1949 | https://oxomi.com/p/3000126/datasheet/-/11600021001 | 0.011
1444968 | Tender Text en | Product URL DE | 15 | 25 | 0.00000516767 | REHAU Compression sleeve RAUTITAN PX 20 | 4007360361211 | 11600021001 | 1949 | https://oxomi.com/p/3000126/datasheet/-/11600021001 | 0.011
1444972 | Tender Text en | Product URL DE | 20 | 27.2 | 0.0000087028 | REHAU Compression sleeve RAUTITAN PX 25 | 4007360361228 | 11600031001 | 1950 | https://oxomi.com/p/3000126/datasheet/-/11600031001 | 0.015828
1444976 | Tender Text en | Product URL DE | 20 | 27.2 | 0.0000087028 | REHAU Compression sleeve RAUTITAN PX 25 | 4007360361228 | 11600031001 | 1950 | https://oxomi.com/p/3000126/datasheet/-/11600031001 | 0.015828
1444980 | Tender Text en | Product URL DE | 25 | 34 | 0.0000174355 | REHAU Compression sleeve RAUTITAN PX 32 | 4007360361235 | 11600041001 | 1951 | https://oxomi.com/p/3000126/datasheet/-/11600041001 | 0.027828
1444984 | Tender Text en | Product URL DE | 25 | 34 | 0.0000174355 | REHAU Compression sleeve RAUTITAN PX 32 | 4007360361235 | 11600041001 | 1951 | https://oxomi.com/p/3000126/datasheet/-/11600041001 | 0.027828
1444988 | Tender Text en | Product URL DE | 25 | 34 | 0.0000174355 | REHAU Compression sleeve RAUTITAN PX 32 | 4007360361235 | 11600041001 | 1951 | https://oxomi.com/p/3000126/datasheet/-/11600041001 | 0.027828
1444992 | Tender Text en | Product URL DE | 32 | 37.8 | 0.0000303041 | REHAU Compression sleeve RAUTITAN PX 40 | 4007360361242 | 11600051001 | 1952 | https://oxomi.com/p/3000126/datasheet/-/11600051001 | 0.03861
1444996 | Tender Text en | Product URL DE | 40 | 45 | 0.0000353695 | REHAU Compr. sleeve RAUTITAN PX stabil 50 | 4062178755416 | 11602061001 | 1954 | https://oxomi.com/p/3000126/datasheet/-/11602061001 | 0.0673
1445000 | Tender Text en | Product URL DE | 50 | 53 | 0.0000702282 | REHAU Compr. sleeve RAUTITAN PX stabil 63 | 4062178755423 | 11602071001 | 1955 | https://oxomi.com/p/3000126/datasheet/-/11602071001 | 0.1106
1445003 | Tender Text en | Product URL DE | 32 | 37.8 | 0.0000303041 | REHAU Compression sleeve RAUTITAN PX 40 | 4007360361242 | 11600051001 | 1952 | https://oxomi.com/p/3000126/datasheet/-/11600051001 | 0.03861
1445004 | Tender Text en | Product URL DE | 25 | 34 | 0.0000174355 | REHAU Compression sleeve RAUTITAN PX 32 | 4007360361235 | 11600041001 | 1951 | https://oxomi.com/p/3000126/datasheet/-/11600041001 | 0.027828
1445005 | Tender Text en | Product URL DE | 12 | 23.7 | 0.00000312848 | REHAU Compression sleeve RAUTITAN PX 16 | 4007360361204 | 11600011001 | 1947 | https://oxomi.com/p/3000126/datasheet/-/11600011001 | 0.0076
1445011 | Tender Text en | Product URL DE | 32 | 37.8 | 0.0000303041 | REHAU Compression sleeve RAUTITAN PX 40 | 4007360361242 | 11600051001 | 1952 | https://oxomi.com/p/3000126/datasheet/-/11600051001 | 0.03861
1445012 | Tender Text en | Product URL DE | 25 | 34 | 0.0000174355 | REHAU Compression sleeve RAUTITAN PX 32 | 4007360361235 | 11600041001 | 1951 | https://oxomi.com/p/3000126/datasheet/-/11600041001 | 0.027828
1445013 | Tender Text en | Product URL DE | 15 | 25 | 0.00000516767 | REHAU Compression sleeve RAUTITAN PX 20 | 4007360361211 | 11600021001 | 1949 | https://oxomi.com/p/3000126/datasheet/-/11600021001 | 0.011
1445021 | Tender Text en | Product URL DE | 15 | 25 | 0.00000516767 | REHAU Compression sleeve RAUTITAN PX 20 | 4007360361211 | 11600021001 | 1949 | https://oxomi.com/p/3000126/datasheet/-/11600021001 | 0.011
1445022 | Tender Text en | Product URL DE | 15 | 25 | 0.00000516767 | REHAU Compression sleeve RAUTITAN PX 20 | 4007360361211 | 11600021001 | 1949 | https://oxomi.com/p/3000126/datasheet/-/11600021001 | 0.011
1445023 | Tender Text en | Product URL DE | 15 | 25 | 0.00000516767 | REHAU Compression sleeve RAUTITAN PX 20 | 4007360361211 | 11600021001 | 1949 | https://oxomi.com/p/3000126/datasheet/-/11600021001 | 0.011
1445029 | Tender Text en | Product URL DE | 15 | 25 | 0.00000516767 | REHAU Compression sleeve RAUTITAN PX 20 | 4007360361211 | 11600021001 | 1949 | https://oxomi.com/p/3000126/datasheet/-/11600021001 | 0.011
1445030 | Tender Text en | Product URL DE | 15 | 25 | 0.00000516767 | REHAU Compression sleeve RAUTITAN PX 20 | 4007360361211 | 11600021001 | 1949 | https://oxomi.com/p/3000126/datasheet/-/11600021001 | 0.011
1445035 | Tender Text en | Product URL DE | 15 | 25 | 0.00000516767 | REHAU Compression sleeve RAUTITAN PX 20 | 4007360361211 | 11600021001 | 1949 | https://oxomi.com/p/3000126/datasheet/-/11600021001 | 0.011
1445039 | Tender Text en | Product URL DE | 15 | 25 | 0.00000516767 | REHAU Compression sleeve RAUTITAN PX 20 | 4007360361211 | 11600021001 | 1949 | https://oxomi.com/p/3000126/datasheet/-/11600021001 | 0.011
1445043 | Tender Text en | Product URL DE | 15 | 25 | 0.00000516767 | REHAU Compression sleeve RAUTITAN PX 20 | 4007360361211 | 11600021001 | 1949 | https://oxomi.com/p/3000126/datasheet/-/11600021001 | 0.011
1445047 | Tender Text en | Product URL DE | 20 | 27.2 | 0.0000087028 | REHAU Compression sleeve RAUTITAN PX 25 | 4007360361228 | 11600031001 | 1950 | https://oxomi.com/p/3000126/datasheet/-/11600031001 | 0.015828
1445051 | Tender Text en | Product URL DE | 20 | 27.2 | 0.0000087028 | REHAU Compression sleeve RAUTITAN PX 25 | 4007360361228 | 11600031001 | 1950 | https://oxomi.com/p/3000126/datasheet/-/11600031001 | 0.015828
1445055 | Tender Text en | Product URL DE | 25 | 34 | 0.0000174355 | REHAU Compression sleeve RAUTITAN PX 32 | 4007360361235 | 11600041001 | 1951 | https://oxomi.com/p/3000126/datasheet/-/11600041001 | 0.027828
1445059 | Tender Text en | Product URL DE | 25 | 34 | 0.0000174355 | REHAU Compression sleeve RAUTITAN PX 32 | 4007360361235 | 11600041001 | 1951 | https://oxomi.com/p/3000126/datasheet/-/11600041001 | 0.027828
1445063 | Tender Text en | Product URL DE | 32 | 37.8 | 0.0000303041 | REHAU Compression sleeve RAUTITAN PX 40 | 4007360361242 | 11600051001 | 1952 | https://oxomi.com/p/3000126/datasheet/-/11600051001 | 0.03861
1445067 | Tender Text en | Product URL DE | 40 | 45 | 0.0000353695 | REHAU Compr. sleeve RAUTITAN PX stabil 50 | 4062178755416 | 11602061001 | 1954 | https://oxomi.com/p/3000126/datasheet/-/11602061001 | 0.0673
1445068 | Tender Text en | Product URL DE | 40 | 45 | 0.0000353695 | REHAU Compr. sleeve RAUTITAN PX stabil 50 | 4062178755416 | 11602061001 | 1954 | https://oxomi.com/p/3000126/datasheet/-/11602061001 | 0.0673
1445079 | Tender Text en | Product URL DE | 50 | 53 | 0.0000702282 | REHAU Compr. sleeve RAUTITAN PX stabil 63 | 4062178755423 | 11602071001 | 1955 | https://oxomi.com/p/3000126/datasheet/-/11602071001 | 0.1106
1445080 | Tender Text en | Product URL DE | 50 | 53 | 0.0000702282 | REHAU Compr. sleeve RAUTITAN PX stabil 63 | 4062178755423 | 11602071001 | 1955 | https://oxomi.com/p/3000126/datasheet/-/11602071001 | 0.1106
1445085 | Tender Text en | Product URL DE | 20 | 27.2 | 0.0000087028 | REHAU Compression sleeve RAUTITAN PX 25 | 4007360361228 | 11600031001 | 1950 | https://oxomi.com/p/3000126/datasheet/-/11600031001 | 0.015828
1445086 | Tender Text en | Product URL DE | 25 | 34 | 0.0000174355 | REHAU Compression sleeve RAUTITAN PX 32 | 4007360361235 | 11600041001 | 1951 | https://oxomi.com/p/3000126/datasheet/-/11600041001 | 0.027828
1445091 | Tender Text en | Product URL DE | 25 | 34 | 0.0000174355 | REHAU Compression sleeve RAUTITAN PX 32 | 4007360361235 | 11600041001 | 1951 | https://oxomi.com/p/3000126/datasheet/-/11600041001 | 0.027828
1445092 | Tender Text en | Product URL DE | 25 | 34 | 0.0000174355 | REHAU Compression sleeve RAUTITAN PX 32 | 4007360361235 | 11600041001 | 1951 | https://oxomi.com/p/3000126/datasheet/-/11600041001 | 0.027828
1445097 | Tender Text en | Product URL DE | 32 | 37.8 | 0.0000303041 | REHAU Compression sleeve RAUTITAN PX 40 | 4007360361242 | 11600051001 | 1952 | https://oxomi.com/p/3000126/datasheet/-/11600051001 | 0.03861
1445098 | Tender Text en | Product URL DE | 32 | 37.8 | 0.0000303041 | REHAU Compression sleeve RAUTITAN PX 40 | 4007360361242 | 11600051001 | 1952 | https://oxomi.com/p/3000126/datasheet/-/11600051001 | 0.03861
1445103 | Tender Text en | Product URL DE | 20 | 27.2 | 0.0000087028 | REHAU Compression sleeve RAUTITAN PX 25 | 4007360361228 | 11600031001 | 1950 | https://oxomi.com/p/3000126/datasheet/-/11600031001 | 0.015828
1445104 | Tender Text en | Product URL DE | 20 | 27.2 | 0.0000087028 | REHAU Compression sleeve RAUTITAN PX 25 | 4007360361228 | 11600031001 | 1950 | https://oxomi.com/p/3000126/datasheet/-/11600031001 | 0.015828
1445109 | Tender Text en | Product URL DE | 25 | 34 | 0.0000174355 | REHAU Compression sleeve RAUTITAN PX 32 | 4007360361235 | 11600041001 | 1951 | https://oxomi.com/p/3000126/datasheet/-/11600041001 | 0.027828
1445110 | Tender Text en | Product URL DE | 25 | 34 | 0.0000174355 | REHAU Compression sleeve RAUTITAN PX 32 | 4007360361235 | 11600041001 | 1951 | https://oxomi.com/p/3000126/datasheet/-/11600041001 | 0.027828
1445115 | Tender Text en | Product URL DE | 15 | 25 | 0.00000516767 | REHAU Compression sleeve RAUTITAN PX 20 | 4007360361211 | 11600021001 | 1949 | https://oxomi.com/p/3000126/datasheet/-/11600021001 | 0.011
1445116 | Tender Text en | Product URL DE | 15 | 25 | 0.00000516767 | REHAU Compression sleeve RAUTITAN PX 20 | 4007360361211 | 11600021001 | 1949 | https://oxomi.com/p/3000126/datasheet/-/11600021001 | 0.011
1445121 | Tender Text en | Product URL DE | 12 | 23.7 | 0.00000312848 | REHAU Compression sleeve RAUTITAN PX 16 | 4007360361204 | 11600011001 | 1947 | https://oxomi.com/p/3000126/datasheet/-/11600011001 | 0.0076
1445122 | Tender Text en | Product URL DE | 12 | 23.7 | 0.00000312848 | REHAU Compression sleeve RAUTITAN PX 16 | 4007360361204 | 11600011001 | 1947 | https://oxomi.com/p/3000126/datasheet/-/11600011001 | 0.0076
1445127 | Tender Text en | Product URL DE | 12 | 23.7 | 0.00000312848 | REHAU Compression sleeve RAUTITAN PX 16 | 4007360361204 | 11600011001 | 1947 | https://oxomi.com/p/3000126/datasheet/-/11600011001 | 0.0076
1445128 | Tender Text en | Product URL DE | 15 | 25 | 0.00000516767 | REHAU Compression sleeve RAUTITAN PX 20 | 4007360361211 | 11600021001 | 1949 | https://oxomi.com/p/3000126/datasheet/-/11600021001 | 0.011
1445133 | Tender Text en | Product URL DE | 15 | 25 | 0.00000516767 | REHAU Compression sleeve RAUTITAN PX 20 | 4007360361211 | 11600021001 | 1949 | https://oxomi.com/p/3000126/datasheet/-/11600021001 | 0.011
1445134 | Tender Text en | Product URL DE | 15 | 25 | 0.00000516767 | REHAU Compression sleeve RAUTITAN PX 20 | 4007360361211 | 11600021001 | 1949 | https://oxomi.com/p/3000126/datasheet/-/11600021001 | 0.011
1447318 | Tender Text en | Product URL DE | 40 | 45 | 0.0000353695 | REHAU Compr. sleeve RAUTITAN PX stabil 50 | 4062178755416 | 11602061001 | 1954 | https://oxomi.com/p/3000126/datasheet/-/11602061001 | 0.0673
1447319 | Tender Text en | Product URL DE | 40 | 45 | 0.0000353695 | REHAU Compr. sleeve RAUTITAN PX stabil 50 | 4062178755416 | 11602061001 | 1954 | https://oxomi.com/p/3000126/datasheet/-/11602061001 | 0.0673
1447324 | Tender Text en | Product URL DE | 50 | 53 | 0.0000702282 | REHAU Compr. sleeve RAUTITAN PX stabil 63 | 4062178755423 | 11602071001 | 1955 | https://oxomi.com/p/3000126/datasheet/-/11602071001 | 0.1106
1447325 | Tender Text en | Product URL DE | 50 | 53 | 0.0000702282 | REHAU Compr. sleeve RAUTITAN PX stabil 63 | 4062178755423 | 11602071001 | 1955 | https://oxomi.com/p/3000126/datasheet/-/11602071001 | 0.1106
1451458 | Tender Text en | Product URL DE | 12 | 23.7 | 0.00000312848 | REHAU Compression sleeve RAUTITAN PX 16 | 4007360361204 | 11600011001 | 1947 | https://oxomi.com/p/3000126/datasheet/-/11600011001 | 0.0076

# IfcFlowSegment: Pipe Types:RAUTITAN Flex LX & RX+ Do (8)
In: REHAU Starting view
Type - Other - Category: Pipes; Family Name: Pipe Types
Type - Identity Data - Assembly Code: 11303701100, 11303801100, 11303901050, 11304001050, 11304101006; Description: Drinking water & heating; Manufacturer: REHAU; Model: RAUTITAN; Type Comments: Do 16-40; Type Name: RAUTITAN Flex LX & RX+ Do; URL: www.rehau.com
Type - Pset_ManufacturerTypeInformation - Manufacturer: REHAU
Classification: 11303701100, 11303801100, 11303901050, 11304001050, 11304101006 (Uniformat)
Pset_DistributionFlowElementCommon - Reference: Pipe Types:RAUTITAN Flex LX & RX+ Do; sets with these values: 2
Pset_DuctConnection - ConnectionType: Generic; sets with these values: 2
Pset_FlowSegmentDuctSegment - Length: 1000 mm
Pset_FlowSegmentPipeSegment - Length: 1000 mm
Other - Family: Pipe Types; Family and Type: Pipe Types: RAUTITAN Flex LX & RX+ Do; Type: RAUTITAN Flex LX & RX+ Do; Type Id: 675180
Constraints - End Middle Elevation: 0 mm; Horizontal Justification: Center; Lower End Centerline Elevation: 0 mm; Middle Elevation: 0 mm; Reference Level: REHAU Starting view; Slope: 0; Start Middle Elevation: 0 mm; Upper End Centerline Elevation: 0 mm; Vertical Justification: Middle
Dimensions - Length: 1000 mm
Mechanical - System Type: Domestic Cold Water; Material: RAUTITAN flex; Connection Type: Generic; Pipe Segment: RAUTITAN flex - Do 12 - 63; Roughness: 0.007 mm; Schedule/Type: Do 12 - 63; System Classification: Domestic Cold Water
Mechanical - Flow - Additional Flow: 0 dm3/s; Fixture Units: 0; Flow: 0 dm3/s; Flow State: Laminar; Friction Factor: 0; Pressure Drop: 0 Pa; Reynolds Number: 0; Section: 1; Velocity: 0 m/s; Velocity Pressure: 0 Pa; Friction: 0 kg/m2/s2
Phasing - Phase Created: New Construction
Insulation - Insulation Thickness: 0 mm
Name (Pipe Types:RAUTITAN Flex LX & RX+ Do:...) | InvertElevation (mm) = Lower End Invert Elevation (mm) = Upper End Invert Elevation (mm) = Invert Elevation (mm) | Lower End Bottom Elevation (mm) = Upper End Bottom Elevation (mm) = Lower End Bottom of Insulation Elevation (mm) = Upper End Bottom of Insulation Elevation (mm) | Lower End Obvert Elevation (mm) = Upper End Obvert Elevation (mm) | Lower End Top Elevation (mm) = Upper End Top Elevation (mm) = Lower End Top of Insulation Elevation (mm) = Upper End Top of Insulation Elevation (mm) | Inside Diameter (mm) | Outside Diameter (mm) = Diameter (mm) | Size = Overall Size | Wall Thickness (mm) | Area (m2) | System Name = Group | Relative Roughness
1150842 | -4.3 | -6 | 4.3 | 6 | 8.6 | 12 | 12 mmø | 1.7 | 0.0376991 | Domestic Cold Water 31 | 0.000813953
1150856 | -5.8 | -8 | 5.8 | 8 | 11.6 | 16 | 16 mmø | 2.2 | 0.0502655 | Domestic Cold Water 38 | 0.000603448
