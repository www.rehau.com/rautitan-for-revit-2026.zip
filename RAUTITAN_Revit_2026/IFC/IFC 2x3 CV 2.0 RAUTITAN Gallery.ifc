Properties of the parts of a building model (IFC2X3), part 2 of 9

# IfcDistributionPort (986)
Name | FlowDirection
Port_1150376_1 | SOURCEANDSINK | Group: Domestic Cold Water 18
Port_1150378_0 | SOURCEANDSINK | Group: Domestic Cold Water 19
Port_1150378_1 | SOURCEANDSINK | Group: Domestic Cold Water 19
Port_1150380_0 | SOURCEANDSINK | Group: Domestic Cold Water 20
Port_1150380_1 | SOURCEANDSINK | Group: Domestic Cold Water 20
Port_1150382_0 | SOURCEANDSINK | Group: Domestic Cold Water 21
Port_1150382_1 | SOURCEANDSINK | Group: Domestic Cold Water 21
Port_1150384_0 | SOURCEANDSINK | Group: Domestic Cold Water 22
Port_1150384_1 | SOURCEANDSINK | Group: Domestic Cold Water 22
Port_1150500_0 | SOURCEANDSINK | Group: Domestic Cold Water 24
Port_1150500_1 | SOURCEANDSINK | Group: Domestic Cold Water 24
Port_1150502_0 | SOURCEANDSINK | Group: Domestic Cold Water 25
Port_1150502_1 | SOURCEANDSINK | Group: Domestic Cold Water 25
Port_1150504_0 | SOURCEANDSINK | Group: Domestic Cold Water 26
Port_1150504_1 | SOURCEANDSINK | Group: Domestic Cold Water 26
Port_1150506_0 | SOURCEANDSINK | Group: Domestic Cold Water 27
Port_1150506_1 | SOURCEANDSINK | Group: Domestic Cold Water 27
Port_1150508_0 | SOURCEANDSINK | Group: Domestic Cold Water 28
Port_1150508_1 | SOURCEANDSINK | Group: Domestic Cold Water 28
Port_1150510_0 | SOURCEANDSINK | Group: Domestic Cold Water 29
Port_1150510_1 | SOURCEANDSINK | Group: Domestic Cold Water 29
Port_1150512_0 | SOURCEANDSINK | Group: Domestic Cold Water 30
Port_1150512_1 | SOURCEANDSINK | Group: Domestic Cold Water 30
Port_1150838_0 | SOURCEANDSINK | Group: Domestic Cold Water 23
Port_1150838_1 | SOURCEANDSINK | Group: Domestic Cold Water 23
Port_1150842_0 | SOURCEANDSINK | Group: Domestic Cold Water 31
Port_1150842_1 | SOURCEANDSINK | Group: Domestic Cold Water 31
Port_1150844_0 | SOURCEANDSINK | Group: Domestic Cold Water 32
Port_1150844_1 | SOURCEANDSINK | Group: Domestic Cold Water 32
Port_1150846_0 | SOURCEANDSINK | Group: Domestic Cold Water 33
Port_1150846_1 | SOURCEANDSINK | Group: Domestic Cold Water 33
Port_1150848_0 | SOURCEANDSINK | Group: Domestic Cold Water 34
Port_1150848_1 | SOURCEANDSINK | Group: Domestic Cold Water 34
Port_1150850_0 | SOURCEANDSINK | Group: Domestic Cold Water 35
Port_1150850_1 | SOURCEANDSINK | Group: Domestic Cold Water 35
Port_1150852_0 | SOURCEANDSINK | Group: Domestic Cold Water 36
Port_1150852_1 | SOURCEANDSINK | Group: Domestic Cold Water 36
Port_1150856_0 | SOURCEANDSINK | Group: Domestic Cold Water 38
Port_1150856_1 | SOURCEANDSINK | Group: Domestic Cold Water 38
Port_1150860_0 | SOURCEANDSINK | Group: Domestic Cold Water 40
Port_1150860_1 | SOURCEANDSINK | Group: Domestic Cold Water 40
Port_1150862_0 | SOURCEANDSINK | Group: Domestic Cold Water 41
Port_1150862_1 | SOURCEANDSINK | Group: Domestic Cold Water 41
Port_1150864_0 | SOURCEANDSINK | Group: Domestic Cold Water 42
Port_1150864_1 | SOURCEANDSINK | Group: Domestic Cold Water 42
Port_1150866_0 | SOURCEANDSINK | Group: Domestic Cold Water 43
Port_1150866_1 | SOURCEANDSINK | Group: Domestic Cold Water 43
Port_1150868_0 | SOURCEANDSINK | Group: Domestic Cold Water 44
Port_1150868_1 | SOURCEANDSINK | Group: Domestic Cold Water 44
Port_1151148_0 | SOURCEANDSINK | Group: Domestic Cold Water 37
Port_1151148_1 | SOURCEANDSINK | Group: Domestic Cold Water 37
Port_1151185_0 | SOURCEANDSINK | Group: Domestic Cold Water 45
Port_1151185_1 | SOURCEANDSINK | Group: Domestic Cold Water 45
Port_1151187_0 | SOURCEANDSINK | Group: Domestic Cold Water 46
Port_1151187_1 | SOURCEANDSINK | Group: Domestic Cold Water 46
Port_1151189_0 | SOURCEANDSINK | Group: Domestic Cold Water 47
Port_1151189_1 | SOURCEANDSINK | Group: Domestic Cold Water 47
Port_1151191_0 | SOURCEANDSINK | Group: Domestic Cold Water 48
Port_1151191_1 | SOURCEANDSINK | Group: Domestic Cold Water 48
Port_1151193_0 | SOURCEANDSINK | Group: Domestic Cold Water 49
Port_1151193_1 | SOURCEANDSINK | Group: Domestic Cold Water 49
Port_1151195_0 | SOURCEANDSINK | Group: Domestic Cold Water 50
Port_1151195_1 | SOURCEANDSINK | Group: Domestic Cold Water 50
Port_1151197_0 | SOURCEANDSINK | Group: Domestic Cold Water 51
Port_1151197_1 | SOURCEANDSINK | Group: Domestic Cold Water 51
Port_1151436_0 | SOURCEANDSINK | Group: Domestic Cold Water 39
Port_1151436_1 | SOURCEANDSINK | Group: Domestic Cold Water 39
Port_1151469_0 | SOURCEANDSINK | Group: Domestic Cold Water 52
Port_1151469_1 | SOURCEANDSINK | Group: Domestic Cold Water 52
Port_1151471_0 | SOURCEANDSINK | Group: Domestic Cold Water 53
Port_1151471_1 | SOURCEANDSINK | Group: Domestic Cold Water 53
Port_1151473_0 | SOURCEANDSINK | Group: Domestic Cold Water 54
Port_1151473_1 | SOURCEANDSINK | Group: Domestic Cold Water 54
Port_1151475_0 | SOURCEANDSINK | Group: Domestic Cold Water 55
Port_1151475_1 | SOURCEANDSINK | Group: Domestic Cold Water 55
Port_1151477_0 | SOURCEANDSINK | Group: Domestic Cold Water 56
Port_1151477_1 | SOURCEANDSINK | Group: Domestic Cold Water 56
Port_1151479_0 | SOURCEANDSINK | Group: Domestic Cold Water 57
Port_1151479_1 | SOURCEANDSINK | Group: Domestic Cold Water 57
Port_1151481_0 | SOURCEANDSINK | Group: Domestic Cold Water 58
Port_1151481_1 | SOURCEANDSINK | Group: Domestic Cold Water 58
InPort_1238073_3 | SINK
InPort_1238073_4 | SINK
InPort_1238318_1 | SINK
InPort_1238318_2 | SINK
InPort_1238578_2 | SINK
InPort_1238578_3 | SINK
InPort_1238596_1 | SINK
InPort_1238596_2 | SINK
InPort_1238842_1 | SINK
InPort_1238842_2 | SINK
InPort_1238953_3 | SINK
InPort_1238953_4 | SINK
InPort_1238964_1 | SINK
InPort_1238964_2 | SINK
InPort_1239135_1 | SINK
InPort_1239135_2 | SINK
InPort_1239146_1 | SINK
InPort_1239146_2 | SINK
InPort_1239298_1 | SINK
InPort_1239298_2 | SINK
InPort_1239436_1 | SINK
InPort_1239436_2 | SINK
InPort_1239510_1 | SINK
InPort_1239510_2 | SINK
InPort_1239526_2 | SINK
InPort_1239526_3 | SINK
InPort_1239654_1 | SINK
InPort_1239654_2 | SINK
Port_1356245_3 | SOURCEANDSINK
Port_1356245_4 | SOURCEANDSINK
Port_1440894_1 | SOURCEANDSINK
Port_1440894_2 | SOURCEANDSINK
Port_1440940_1 | SOURCEANDSINK
Port_1440940_2 | SOURCEANDSINK
Port_1441230_1 | SOURCEANDSINK
Port_1441230_2 | SOURCEANDSINK
Port_1441482_1 | SOURCEANDSINK
Port_1441482_2 | SOURCEANDSINK
Port_1441482_3 | SOURCEANDSINK
Port_1441702_2 | SOURCEANDSINK
Port_1441702_3 | SOURCEANDSINK
Port_1441967_2 | SOURCEANDSINK
Port_1441967_3 | SOURCEANDSINK
Port_1442034_2 | SOURCEANDSINK
Port_1442034_3 | SOURCEANDSINK
Port_1442377_1 | SOURCEANDSINK
Port_1442377_2 | SOURCEANDSINK
Port_1442377_3 | SOURCEANDSINK
Port_1442400_1 | SOURCEANDSINK
Port_1442400_2 | SOURCEANDSINK
Port_1442404_1 | SOURCEANDSINK
Port_1442404_2 | SOURCEANDSINK
Port_1442918_2 | SOURCEANDSINK
Port_1442918_3 | SOURCEANDSINK
Port_1442920_2 | SOURCEANDSINK
Port_1442920_3 | SOURCEANDSINK
Port_1442922_2 | SOURCEANDSINK
Port_1442922_3 | SOURCEANDSINK
Port_1442924_2 | SOURCEANDSINK
Port_1442924_3 | SOURCEANDSINK
Port_1442926_2 | SOURCEANDSINK
Port_1442926_3 | SOURCEANDSINK
Port_1442928_2 | SOURCEANDSINK
Port_1442928_3 | SOURCEANDSINK
Port_1442930_2 | SOURCEANDSINK
Port_1442930_3 | SOURCEANDSINK
Port_1442932_2 | SOURCEANDSINK
Port_1442932_3 | SOURCEANDSINK
Port_1442934_2 | SOURCEANDSINK
Port_1442934_3 | SOURCEANDSINK
Port_1442936_2 | SOURCEANDSINK
Port_1442936_3 | SOURCEANDSINK
Port_1442938_2 | SOURCEANDSINK
Port_1442938_3 | SOURCEANDSINK
Port_1443065_2 | SOURCEANDSINK
Port_1443065_3 | SOURCEANDSINK
Port_1443069_2 | SOURCEANDSINK
Port_1443069_3 | SOURCEANDSINK
Port_1443131_2 | SOURCEANDSINK
Port_1443131_3 | SOURCEANDSINK
Port_1443285_2 | SOURCEANDSINK
Port_1443285_3 | SOURCEANDSINK
Port_1443667_4 | SOURCEANDSINK
Port_1443667_5 | SOURCEANDSINK
Port_1443731_4 | SOURCEANDSINK
Port_1443731_5 | SOURCEANDSINK
Port_1443735_4 | SOURCEANDSINK
Port_1443735_5 | SOURCEANDSINK
Port_1443739_4 | SOURCEANDSINK
Port_1443739_5 | SOURCEANDSINK
Port_1443743_4 | SOURCEANDSINK
Port_1443743_5 | SOURCEANDSINK
Port_1443747_4 | SOURCEANDSINK
Port_1443747_5 | SOURCEANDSINK
Port_1443751_4 | SOURCEANDSINK
Port_1443751_5 | SOURCEANDSINK
Port_1443755_4 | SOURCEANDSINK
Port_1443755_5 | SOURCEANDSINK
Port_1443803_4 | SOURCEANDSINK
Port_1443803_5 | SOURCEANDSINK
Port_1443947_2 | SOURCEANDSINK
Port_1443947_3 | SOURCEANDSINK
Port_1443949_2 | SOURCEANDSINK
Port_1443949_3 | SOURCEANDSINK
Port_1443951_2 | SOURCEANDSINK
Port_1443951_3 | SOURCEANDSINK
Port_1443953_2 | SOURCEANDSINK
Port_1443953_3 | SOURCEANDSINK
Port_1443955_2 | SOURCEANDSINK
Port_1443955_3 | SOURCEANDSINK
Port_1443957_2 | SOURCEANDSINK
Port_1443957_3 | SOURCEANDSINK
Port_1443959_2 | SOURCEANDSINK
Port_1443959_3 | SOURCEANDSINK
Port_1443961_2 | SOURCEANDSINK
Port_1443961_3 | SOURCEANDSINK
Port_1444107_2 | SOURCEANDSINK
Port_1444107_3 | SOURCEANDSINK
Port_1444109_2 | SOURCEANDSINK
Port_1444109_3 | SOURCEANDSINK
Port_1444129_2 | SOURCEANDSINK
Port_1444129_3 | SOURCEANDSINK
Port_1444131_2 | SOURCEANDSINK
Port_1444131_3 | SOURCEANDSINK
Port_1444898_1 | SOURCEANDSINK
Port_1444898_2 | SOURCEANDSINK
Port_1444902_1 | SOURCEANDSINK
Port_1444902_2 | SOURCEANDSINK
Port_1444902_3 | SOURCEANDSINK
Port_1444910_1 | SOURCEANDSINK
Port_1444912_1 | SOURCEANDSINK
Port_1444912_2 | SOURCEANDSINK
Port_1444912_5 | SOURCEANDSINK
Port_1444912_6 | SOURCEANDSINK
Port_1444918_1 | SOURCEANDSINK
Port_1444918_2 | SOURCEANDSINK
Port_1444918_3 | SOURCEANDSINK
Port_1444918_4 | SOURCEANDSINK
Port_1444918_5 | SOURCEANDSINK
Port_1444926_1 | SOURCEANDSINK
Port_1444930_1 | SOURCEANDSINK
Port_1444930_2 | SOURCEANDSINK
Port_1444940_1 | SOURCEANDSINK
Port_1444940_2 | SOURCEANDSINK
Port_1444940_3 | SOURCEANDSINK
Port_1444946_1 | SOURCEANDSINK
Port_1444946_2 | SOURCEANDSINK
Port_1444946_3 | SOURCEANDSINK
Port_1444952_1 | SOURCEANDSINK
Port_1444952_2 | SOURCEANDSINK
Port_1444952_3 | SOURCEANDSINK
Port_1444958_1 | SOURCEANDSINK
Port_1444958_2 | SOURCEANDSINK
Port_1444962_1 | SOURCEANDSINK
Port_1444962_2 | SOURCEANDSINK
Port_1444966_1 | SOURCEANDSINK
Port_1444966_2 | SOURCEANDSINK
Port_1444970_1 | SOURCEANDSINK
Port_1444970_2 | SOURCEANDSINK
Port_1444974_1 | SOURCEANDSINK
Port_1444974_2 | SOURCEANDSINK
Port_1444978_1 | SOURCEANDSINK
Port_1444978_2 | SOURCEANDSINK
Port_1444982_1 | SOURCEANDSINK
Port_1444982_2 | SOURCEANDSINK
Port_1444986_1 | SOURCEANDSINK
Port_1444986_2 | SOURCEANDSINK
Port_1444990_1 | SOURCEANDSINK
Port_1444990_2 | SOURCEANDSINK
Port_1444994_1 | SOURCEANDSINK
Port_1444994_2 | SOURCEANDSINK
Port_1444998_1 | SOURCEANDSINK
Port_1444998_2 | SOURCEANDSINK
Port_1445002_1 | SOURCEANDSINK
Port_1445002_2 | SOURCEANDSINK
Port_1445002_3 | SOURCEANDSINK
Port_1445010_1 | SOURCEANDSINK
Port_1445010_2 | SOURCEANDSINK
Port_1445010_3 | SOURCEANDSINK
Port_1445018_1 | SOURCEANDSINK
Port_1445020_1 | SOURCEANDSINK
Port_1445020_2 | SOURCEANDSINK
Port_1445020_3 | SOURCEANDSINK
Port_1445020_4 | SOURCEANDSINK
Port_1445020_5 | SOURCEANDSINK
Port_1445028_1 | SOURCEANDSINK
Port_1445028_2 | SOURCEANDSINK
Port_1445028_5 | SOURCEANDSINK
Port_1445028_6 | SOURCEANDSINK
Port_1445034_1 | SOURCEANDSINK
Port_1445038_1 | SOURCEANDSINK
Port_1445038_2 | SOURCEANDSINK
Port_1445042_1 | SOURCEANDSINK
Port_1445042_2 | SOURCEANDSINK
Port_1445046_1 | SOURCEANDSINK
Port_1445046_2 | SOURCEANDSINK
Port_1445050_1 | SOURCEANDSINK
Port_1445050_2 | SOURCEANDSINK
Port_1445054_1 | SOURCEANDSINK
Port_1445054_2 | SOURCEANDSINK
Port_1445058_1 | SOURCEANDSINK
Port_1445058_2 | SOURCEANDSINK
Port_1445062_1 | SOURCEANDSINK
Port_1445062_2 | SOURCEANDSINK
Port_1445066_1 | SOURCEANDSINK
Port_1445066_2 | SOURCEANDSINK
Port_1445066_3 | SOURCEANDSINK
Port_1445078_1 | SOURCEANDSINK
Port_1445078_2 | SOURCEANDSINK
Port_1445078_3 | SOURCEANDSINK
Port_1445084_1 | SOURCEANDSINK
Port_1445084_2 | SOURCEANDSINK
Port_1445084_3 | SOURCEANDSINK
Port_1445090_1 | SOURCEANDSINK
Port_1445090_2 | SOURCEANDSINK
Port_1445090_3 | SOURCEANDSINK
Port_1445096_1 | SOURCEANDSINK
Port_1445096_2 | SOURCEANDSINK
Port_1445096_3 | SOURCEANDSINK
Port_1445102_1 | SOURCEANDSINK
Port_1445102_2 | SOURCEANDSINK
Port_1445102_3 | SOURCEANDSINK
Port_1445108_1 | SOURCEANDSINK
Port_1445108_2 | SOURCEANDSINK
Port_1445108_3 | SOURCEANDSINK
Port_1445114_1 | SOURCEANDSINK
Port_1445114_2 | SOURCEANDSINK
Port_1445114_3 | SOURCEANDSINK
Port_1445120_1 | SOURCEANDSINK
Port_1445120_2 | SOURCEANDSINK
Port_1445120_3 | SOURCEANDSINK
Port_1445126_1 | SOURCEANDSINK
Port_1445126_2 | SOURCEANDSINK
Port_1445126_3 | SOURCEANDSINK
Port_1445132_1 | SOURCEANDSINK
Port_1445132_2 | SOURCEANDSINK
Port_1445132_3 | SOURCEANDSINK
Port_1447317_1 | SOURCEANDSINK
Port_1447317_2 | SOURCEANDSINK
Port_1447317_3 | SOURCEANDSINK
Port_1447323_1 | SOURCEANDSINK
Port_1447323_2 | SOURCEANDSINK
Port_1447323_3 | SOURCEANDSINK
Port_1447698_1 | SOURCEANDSINK
Port_1447698_2 | SOURCEANDSINK
Port_1447702_1 | SOURCEANDSINK
Port_1447702_2 | SOURCEANDSINK
Port_1447706_1 | SOURCEANDSINK
Port_1447706_2 | SOURCEANDSINK
Port_1447710_1 | SOURCEANDSINK
Port_1447710_2 | SOURCEANDSINK
Port_1447714_1 | SOURCEANDSINK
Port_1447714_2 | SOURCEANDSINK
Port_1447718_1 | SOURCEANDSINK
Port_1447718_2 | SOURCEANDSINK
Port_1447722_1 | SOURCEANDSINK
Port_1447722_2 | SOURCEANDSINK
Port_1447726_1 | SOURCEANDSINK
Port_1447726_2 | SOURCEANDSINK
Port_1451456_1 | SOURCEANDSINK
Port_1451456_2 | SOURCEANDSINK
Port_1454191_1 | SOURCEANDSINK
Port_1454191_2 | SOURCEANDSINK

# IfcFlowFitting: RAUTITAN_Adapter_external_thread LX+G_LX:RTI A external LX+G_LX DE (10)
In: REHAU Starting view
Type - Material: Brass
Type - Other - Category: Pipe Fittings; Family Name: RAUTITAN_Adapter_external_thread LX+G_LX; T1: RTI Adapter external thread LX+G_LX; T2: RTI Adapter external thread LX+G_LX DN1+2
Type - Constraints - Default Elevation: 0 mm
Type - Data - Language: Description de; Region Check: Check DE; Region PID: PID DE
Type - Identity Data - Assembly Code: D2090800; Manufacturer: REHAU; Model: RAUTITAN; REHAU Info: 2024.11.21-419114-419114; Type Name: RTI A external LX+G_LX DE
Type - Pset_ManufacturerTypeInformation - Manufacturer: REHAU
Classification: D2090800 (Uniformat)
Pset_DistributionFlowElementCommon - Reference: RAUTITAN_Adapter_external_thread LX+G_LX:RTI A external LX+G_LX DE; sets with these values: 2
Other - IsCustom: no; Family: RAUTITAN_Adapter_external_thread LX+G_LX; Family and Type: RAUTITAN_Adapter_external_thread LX+G_LX: RTI A external LX+G_LX DE; Type: RTI A external LX+G_LX DE; Type Id: 1089349
Constraints - Elevation from Level: 0 mm; Level: REHAU Starting view
Data - PID Check: 1 mm
Dimensions - Area: 0.00465431 m2
Graphics - Use Annotation Scale: no
Identity Data - ETIM Class code: EC003025
Mechanical - System Classification: Undefined
Phasing - Phase Created: New Construction
Insulation - Insulation Thickness: 0 mm
Name (RAUTITAN_Adapter_external_thread LX+G_LX:RTI A external LX+G_LX DE:...) | A (deg) | DN1 (mm) | DN2 (mm) | ID1 (mm) | ID2 (mm) | Maximum Size (mm) | Minimum Size (mm) | Size = Overall Size | SWL (mm) | SWL/2 (mm) | Volume (m3) | Z1 (mm) | Z2 (mm) | Description long | GTIN | PID | Weight
1443947 | 60 | 20 | 15 | 15.2 | 15 | 20 | 15 | 20 mmø-15 mmø | 22 | 11 | 0.00001245 | 3.54 | 11.17 | REHAU Übergang RAUTITAN LX +G 25 - R 1/2 | 4007360543273 | 13129961001 | 0.089
1443949 | 60 | 20 | 20 | 15.2 | 19 | 20 | 20 | 20 mmø-20 mmø | 22 | 11 | 0.0000147651 | 3.54 | 13.68 | REHAU Übergang RAUTITAN LX +G 25 - R 3/4 | 4007360543280 | 13129971001 | 0.105
1443951 | 45 | 20 | 25 | 15.2 | 25.5 | 25 | 20 | 25 mmø-20 mmø | 34 | 17 | 0.0000178754 | 9.72 | 6.7 | REHAU Übergang RAUTITAN LX +G 25 - R 1 | 4007360543297 | 13129981001 | 0.17
1443953 | 60 | 25 | 20 | 20 | 19 | 25 | 20 | 25 mmø-20 mmø | 27 | 13.5 | 0.0000218589 | 4.33 | 12.65 | REHAU Übergang RAUTITAN LX +G 32 - R 3/4 | 4007360543303 | 13129991001 | 0.154
1443955 | 60 | 25 | 25 | 20 | 25.5 | 25 | 25 | 25 mmø-25 mmø | 27 | 13.5 | 0.0000240241 | 4.33 | 14.19 | REHAU Übergang RAUTITAN LX +G 32 - R 1 | 4007360543310 | 13130581001 | 0.198
1443957 | 60 | 32 | 32 | 23.5 | 32 | 32 | 32 | 32 mmø-32 mmø | 32 | 16 | 0.0000461137 | 5.5 | 18.17 | REHAU Übergang RAUTITAN LX +G 40 - R 1 1/4 | 4007360543327 | 13130601001 | 0.358
1443959 | 60 | 40 | 40 | 30.5 | 37.5 | 40 | 40 | 40 mmø-40 mmø | 40 | 20 | 0.0000679767 | 5.25 | 18.29 | REHAU Übergang SDR 7,4 LX 50 - R 1 1/2 | 4007360459710 | 11681111001 | 0.516
1443961 | 60 | 50 | 50 | 39.5 | 49.5 | 50 | 50 | 50 mmø-50 mmø | 49 | 24.5 | 0.000110526 | 5.77 | 19.68 | REHAU Übergang SDR 7,4 LX 63 - R 2 | 4007360459635 | 11681131001 | 0.831
1444107 | 60 | 15 | 15 | 12.5 | 15 | 15 | 15 | 15 mmø-15 mmø | 18 | 9 | 0.00000872263 | 3.33 | 13.11 | REHAU Übergang RAUTITAN LX +G 20 - R 1/2 | 4007360543259 | 13129941001 | 0.07
1444109 | 60 | 15 | 20 | 12.5 | 19 | 20 | 15 | 20 mmø-15 mmø | 18 | 9 | 0.0000100112 | 3.35 | 13.11 | REHAU Übergang RAUTITAN LX +G 20 - R 3/4 | 4007360543266 | 13129951001 | 0.073

# IfcFlowFitting: RAUTITAN_Adapter_external_thread LX+G_LX:RTI A external LX+G_LX DE (2)
In: REHAU Starting view
Type - Material: Error, Brass
Type - Other - Category: Pipe Fittings; Family Name: RAUTITAN_Adapter_external_thread LX+G_LX; T1: RTI Adapter external thread LX+G_LX; T2: RTI Adapter external thread LX+G_LX DN1+2
Type - Constraints - Default Elevation: 0 mm
Type - Data - Language: Description de; Region Check: Check DE; Region PID: PID DE
Type - Identity Data - Assembly Code: D2090800; Manufacturer: REHAU; Model: RAUTITAN; REHAU Info: 2024.11.21-419114-419114; Type Name: RTI A external LX+G_LX DE
Type - Pset_ManufacturerTypeInformation - Manufacturer: REHAU
Classification: D2090800 (Uniformat)
Pset_DistributionFlowElementCommon - Reference: RAUTITAN_Adapter_external_thread LX+G_LX:RTI A external LX+G_LX DE; sets with these values: 2
Other - IsCustom: yes; A: 45 deg; Family: RAUTITAN_Adapter_external_thread LX+G_LX; Family and Type: RAUTITAN_Adapter_external_thread LX+G_LX: RTI A external LX+G_LX DE; Type: RTI A external LX+G_LX DE; Type Id: 1089349
Constraints - Elevation from Level: 0 mm; Level: REHAU Starting view
Data - PID Check: 0 mm
Dimensions - Area: 0.00465431 m2; DN1: 12 mm; ID1: 9.9 mm; Minimum Size: 12 mm; Volume: 0.0000321717 m3; Z1: 8.97 mm
Graphics - Use Annotation Scale: no
Identity Data - ETIM Class code: EC003025; PID: -
Mechanical - System Classification: Undefined
Phasing - Phase Created: New Construction
Insulation - Insulation Thickness: 0 mm
Name (RAUTITAN_Adapter_external_thread LX+G_LX:RTI A external LX+G_LX DE:...) | DN2 (mm) = Maximum Size (mm) | ID2 (mm) | Size = Overall Size | SWL (mm) | SWL/2 (mm) | Z2 (mm) | Description long | GTIN | Weight
1444129 | 15 | 15 | 15 mmø-12 mmø | 21 | 10.5 | 7.72 | REHAU Übergang RAUTITAN LX +G 16 - R 1/2 | 4007360543235 | 0.062
1444131 | 20 | 19 | 20 mmø-12 mmø | 27 | 13.5 | 6.5 | REHAU Übergang RAUTITAN LX +G 16 - R 3/4 | 4007360543242 | 0.07

# IfcFlowFitting: RAUTITAN_Adapter_external_thread:RTI A external DE (14)
In: REHAU Starting view
Type - Material: RAUTITAN RX+
Type - Other - Category: Pipe Fittings; Family Name: RAUTITAN_Adapter_external_thread; T1: RTI Adapter external thread; T2: RTI Adapter external thread DN1+2
Type - Constraints - Default Elevation: 0 mm
Type - Data - Language: Description de; Region Check: Check DE; Region PID: PID DE
Type - Identity Data - Assembly Code: D2090800; Manufacturer: REHAU; Model: RAUTITAN; REHAU Info: 2024.11.21-419114-419114; Type Name: RTI A external DE
Type - Pset_ManufacturerTypeInformation - Manufacturer: REHAU
Classification: D2090800 (Uniformat)
Pset_DistributionFlowElementCommon - Reference: RAUTITAN_Adapter_external_thread:RTI A external DE; sets with these values: 2
Other - IsCustom: no; Family: RAUTITAN_Adapter_external_thread; Family and Type: RAUTITAN_Adapter_external_thread: RTI A external DE; Type: RTI A external DE; Type Id: 1089350
Constraints - Elevation from Level: 0 mm; Level: REHAU Starting view
Data - PID Check: 1 mm
Dimensions - Area: 0.00465431 m2
Graphics - Use Annotation Scale: no
Identity Data - ETIM Class code: EC003025
Mechanical - System Classification: Undefined
Phasing - Phase Created: New Construction
Insulation - Insulation Thickness: 0 mm
Name (RAUTITAN_Adapter_external_thread:RTI A external DE:...) | A (deg) | DN1 (mm) | DN2 (mm) | ID1 (mm) | ID2 (mm) | Maximum Size (mm) | Minimum Size (mm) | Size = Overall Size | SWL (mm) | SWL/2 (mm) | Volume (m3) | Z1 (mm) | Z2 (mm) | Description long | GTIN | PID | Weight
1441702 | 45 | 12 | 15 | 9.9 | 15 | 15 | 12 | 15 mmø-12 mmø | 21 | 10.5 | 0.00000682737 | 8.97 | 7.72 | REHAU Übergang RAUTITAN RX+ 16 - R 1/2 | 4061264397257 | 14563111001 | 0.049
1442918 | 45 | 12 | 20 | 9.9 | 19 | 20 | 12 | 20 mmø-12 mmø | 27 | 13.5 | 0.00000953155 | 8.97 | 6.5 | REHAU Übergang RAUTITAN RX+ 16 - R 3/4 | 4061264397264 | 14563121001 | 0.072
1442920 | 60 | 15 | 15 | 12.5 | 15 | 15 | 15 | 15 mmø-15 mmø | 18 | 9 | 0.00000872263 | 3.33 | 13.11 | REHAU Übergang RAUTITAN RX+ 20 - R 1/2 | 4061264397288 | 14563141001 | 0.06
1442922 | 60 | 15 | 20 | 12.5 | 19 | 20 | 15 | 20 mmø-15 mmø | 18 | 9 | 0.0000100112 | 3.35 | 13.11 | REHAU Übergang RAUTITAN RX+ 20 - R 3/4 | 4061264397295 | 14563151001 | 0.074
1442924 | 60 | 20 | 15 | 15.2 | 15 | 20 | 15 | 20 mmø-15 mmø | 22 | 11 | 0.00001245 | 3.54 | 11.17 | REHAU Übergang RAUTITAN RX+ 25 - R 1/2 | 4061264397318 | 14563171001 | 0.088
1442926 | 60 | 20 | 20 | 15.2 | 19 | 20 | 20 | 20 mmø-20 mmø | 22 | 11 | 0.0000147651 | 3.54 | 13.68 | REHAU Übergang RAUTITAN RX+ 25 - R 3/4 | 4061264397325 | 14563181001 | 0.102
1442928 | 45 | 20 | 25 | 15.2 | 25.5 | 25 | 20 | 25 mmø-20 mmø | 34 | 17 | 0.0000178754 | 9.72 | 6.7 | REHAU Übergang RAUTITAN RX+ 25 - R 1 | 4061264397332 | 14563191001 | 0.132
1442930 | 60 | 25 | 20 | 20 | 19 | 25 | 20 | 25 mmø-20 mmø | 27 | 13.5 | 0.0000218589 | 4.33 | 12.65 | REHAU Übergang RAUTITAN RX+ 32 - R 3/4 | 4061264397349 | 14563201001 | 0.146
1442932 | 60 | 25 | 25 | 20 | 25.5 | 25 | 25 | 25 mmø-25 mmø | 27 | 13.5 | 0.0000240241 | 4.33 | 14.19 | REHAU Übergang RAUTITAN RX+ 32 - R 1 | 4061264397356 | 14563211001 | 0.16
1442934 | 60 | 32 | 32 | 23.5 | 32 | 32 | 32 | 32 mmø-32 mmø | 32 | 16 | 0.0000461137 | 5.5 | 18.17 | REHAU Übergang RAUTITAN RX+ 40 - R 1 1/4 | 4061264397370 | 14563231001 | 0.325
1442936 | 60 | 40 | 40 | 30.5 | 37.5 | 40 | 40 | 40 mmø-40 mmø | 40 | 20 | 0.0000679767 | 5.25 | 18.29 | REHAU Übergang RAUTITAN RX+ 50 - R 1 1/2 | 4061264397394 | 14563251001 | 0.464
1442938 | 60 | 50 | 50 | 39.5 | 49.5 | 50 | 50 | 50 mmø-50 mmø | 49 | 24.5 | 0.000110526 | 5.77 | 19.68 | REHAU Übergang RAUTITAN RX+ 63 - R 2 | 4061264397400 | 14563261001 | 0.76
1443131 | 45 | 12 | 25 | 9.9 | 25.5 | 25 | 12 | 25 mmø-12 mmø | 34 | 17 | 0.000014868 | 8.97 | 7.87 | REHAU Übergang RAUTITAN RX+ 16 - R 1 | 4061264397271 | 14563131001 | 0.105
1443285 | 45 | 15 | 25 | 12.5 | 25.5 | 25 | 15 | 25 mmø-15 mmø | 34 | 17 | 0.0000150441 | 9.44 | 6.76 | REHAU Übergang RAUTITAN RX+ 20 - R 1 | 4061264397301 | 14563161001 | 0.115

# IfcFlowFitting: RAUTITAN_Ball valve block elbow:RAUTITAN_Ball valve block elbow, RAUTITAN_Ball valve block elbow:RAUTITAN_Ball valve block elbow:1087023
In: REHAU Starting view
Type - Material: Brass silver
Type - Other - Category: Pipe Fittings; Family Name: RAUTITAN_Ball valve block elbow; T1: RTI_Ball valve block elbow
Type - Constraints - Default Elevation: 0 mm
Type - Data - Language: Description EN; Region Check: Check DE; Region PID: PID DE
Type - Identity Data - Manufacturer: REHAU; Model: RAUTITAN; Type Name: RAUTITAN_Ball valve block elbow
Type - Pset_ManufacturerTypeInformation - Manufacturer: REHAU
Pset_DistributionFlowElementCommon - Reference: RAUTITAN_Ball valve block elbow:RAUTITAN_Ball valve block elbow; sets with these values: 2
Other - IsCustom: no; Family: RAUTITAN_Ball valve block elbow; Family and Type: RAUTITAN_Ball valve block elbow: RAUTITAN_Ball valve block elbow; Type: RAUTITAN_Ball valve block elbow; Type Id: 1089489
Constraints - Elevation from Level: 0 mm; Level: REHAU Starting view; Moves With Nearby Elements: no
Data - PID Check: 1 mm
Dimensions - Area: 0.0175132 m2; Volume: 0.0000583847 m3
Identity Data - Description long: REHAU Ball valve block male G 1/2 x G 3/4, elbow; GTIN: 4007360190996; PID: 12407371001; Weight: 472
Phasing - Phase Created: New Construction
Insulation - Insulation Thickness: 0 mm

# IfcFlowFitting: RAUTITAN_Ball valve block transition:RAUTITAN_Ball valve block transition, RAUTITAN_Ball valve block transition:RAUTITAN_Ball valve block transition:1087025
In: REHAU Starting view
Type - Material: Brass silver
Type - Other - Category: Pipe Fittings; Family Name: RAUTITAN_Ball valve block transition; T1: RTI_Ball valve block transition
Type - Constraints - Default Elevation: 0 mm
Type - Data - Language: Description EN; Region Check: Check DE; Region PID: PID DE
Type - Identity Data - Manufacturer: REHAU; Model: RAUTITAN; Type Name: RAUTITAN_Ball valve block transition
Type - Pset_ManufacturerTypeInformation - Manufacturer: REHAU
Pset_DistributionFlowElementCommon - Reference: RAUTITAN_Ball valve block transition:RAUTITAN_Ball valve block transition; sets with these values: 2
Other - IsCustom: no; Family: RAUTITAN_Ball valve block transition; Family and Type: RAUTITAN_Ball valve block transition: RAUTITAN_Ball valve block transition; Type: RAUTITAN_Ball valve block transition; Type Id: 1089491
Constraints - Elevation from Level: 0 mm; Level: REHAU Starting view; Moves With Nearby Elements: no
Data - PID Check: 1 mm
Dimensions - Area: 0.0125872 m2; Volume: 0.0000394414 m3
Identity Data - Description long: REHAU Ball valve block male G 1/2 x G 3/4, transition; GTIN: 4007360190989; PID: 12407271001; Weight: 348
Phasing - Phase Created: New Construction
Insulation - Insulation Thickness: 0 mm

# IfcFlowFitting: RAUTITAN_Corner_LX:RTI LX C DN (8)
In: REHAU Starting view
Type - Material: Br
Type - Other - Category: Pipe Fittings; Family Name: RAUTITAN_Corner_LX; Max sleeve: 32 mm; Min sleeve: 12 mm; Sleeve LX: Sleeve : LX 7,4; Sleeve PX: Sleeve : LX 7,4; T1: RTI Corner LX; T2: RTI Corner LX P1
Type - Constraints - Default Elevation: 0 mm
Type - Data - Language: Description en; Language Tender Text: Tender Text en; Region Check: Check DE; Region PID: PID DE; Region URL: Product URL DE; T3: Sleeve DN
Type - Identity Data - Assembly Code: D2090800; Classification Number: 23.60.30.11.14; Manufacturer: REHAU; Model: RAUTITAN; REHAU Info: 14.02.2024-420668-420668; Type Name: RTI LX C DN
Type - Materials and Finishes - Mat. Error: Error; Mat. Fitting: Br
Type - Mechanical - K Coefficient: 3.6; K Coefficient Table: Regular 45, 90 and 180 Elbow; Loss Method: K Coefficient
Type - Pset_ManufacturerTypeInformation - Manufacturer: REHAU
Classification: D2090800 (Uniformat)
Pset_DistributionFlowElementCommon - Reference: RAUTITAN_Corner_LX:RTI LX C DN; sets with these values: 2
Other - Family: RAUTITAN_Corner_LX; Family and Type: RAUTITAN_Corner_LX: RTI LX C DN; Sleeve DN1: Sleeve : LX 7,4; Sleeve DN2: Sleeve : LX 7,4; Type: RTI LX C DN; Type Id: 767005; IsCustom: no
Constraints - Elevation from Level: 0 mm; Level: REHAU Starting view
Data - PID Check: 1 mm
Dimensions - Area: 0.00465431 m2
Graphics - Use Annotation Scale: no
Identity Data - Sorting: 0; ETIM Class: EC003024; ETIM Group: EG015540; ETIM Name: Fitting with 2 connections; Tender text: -
Mechanical - System Classification: Undefined
Phasing - Phase Created: New Construction
Insulation - Insulation Thickness: 0 mm
Name (RAUTITAN_Corner_LX:RTI LX C DN:...) | L1 (mm) | L2 (mm) | Angle (deg) | Di1 (mm) | DN1 (mm) = DN2 (mm) = Maximum Size (mm) = Minimum Size (mm) | Size = Overall Size | Volume (m3) | Description long | GTIN | PID | Product Group | Product URL | Weight
885472 | 19.7 | 23.5 | 90 | 12.5 | 15 | 15 mmø-15 mmø | 0.0000144354 | REHAU Elbow RAUTITAN LX +G 20 - 20, 90 degree | 4007360543174 | 13129861001 | 1686 | https://oxomi.com/p/3000126/datasheet/-/13129861001 | 0.1
885485 | 23.4 | 27.6 | 90 | 15.2 | 20 | 20 mmø-20 mmø | 0.000027148 | REHAU Elbow RAUTITAN LX +G 25 - 25, 90 degree | 4007360543181 | 13129871001 | 1689 | https://oxomi.com/p/3000126/datasheet/-/13129871001 | 0.16
885598 | 26.5 | 31.5 | 90 | 20 | 25 | 25 mmø-25 mmø | 0.0000378291 | REHAU Elbow RAUTITAN LX +G 32 - 32, 90 degree | 4007360543198 | 13129881001 | 1690 | https://oxomi.com/p/3000126/datasheet/-/13129881001 | 0.31
885683 | 33 | 40 | 90 | 23 | 32 | 32 mmø-32 mmø | 0.0000748314 | REHAU Elbow RAUTITAN LX +G 40 - 40, 90 degree | 4007360543204 | 13129891001 | 1691 | https://oxomi.com/p/3000126/datasheet/-/13129891001 | 0.59
885698 | 39 | 46 | 90 | 30 | 40 | 40 mmø-40 mmø | 0.000112783 | REHAU Elbow RAUTITAN LX 50 - 50, 90 degree | 4007360458768 | 11681531001 | 1675 | https://oxomi.com/p/3000126/datasheet/-/11681531001 | 0.96
885872 | 45.5 | 54 | 90 | 39 | 50 | 50 mmø-50 mmø | 0.000183732 | REHAU Elbow RAUTITAN LX 63 - 63, 90 degree | 4007360458720 | 11681551001 | 1676 | https://oxomi.com/p/3000126/datasheet/-/11681551001 | 1.4
885987 | 20.8 | 29.3 | 45 | 39 | 50 | 50 mmø-50 mmø | 0.000151105 | REHAU Elbow RAUTITAN LX 63 - 63, 45 degree | 4007360458713 | 11681541001 | 1668 | https://oxomi.com/p/3000126/datasheet/-/11681541001 | 1.27
886085 | 19 | 26 | 45 | 30 | 40 | 40 mmø-40 mmø | 0.0000917925 | REHAU Elbow RAUTITAN LX 50 - 50, 45 degree | 4007360458751 | 11681521001 | 1667 | https://oxomi.com/p/3000126/datasheet/-/11681521001 | 0.72

# IfcFlowFitting: RAUTITAN_Corner_LX:RTI LX C DN (2)
In: REHAU Starting view
Type - Material: Error, Br
Type - Other - Category: Pipe Fittings; Family Name: RAUTITAN_Corner_LX; Max sleeve: 32 mm; Min sleeve: 12 mm; Sleeve LX: Sleeve : LX 7,4; Sleeve PX: Sleeve : LX 7,4; T1: RTI Corner LX; T2: RTI Corner LX P1
Type - Constraints - Default Elevation: 0 mm
Type - Data - Language: Description en; Language Tender Text: Tender Text en; Region Check: Check DE; Region PID: PID DE; Region URL: Product URL DE; T3: Sleeve DN
Type - Identity Data - Assembly Code: D2090800; Classification Number: 23.60.30.11.14; Manufacturer: REHAU; Model: RAUTITAN; REHAU Info: 14.02.2024-420668-420668; Type Name: RTI LX C DN
Type - Materials and Finishes - Mat. Error: Error; Mat. Fitting: Br
Type - Mechanical - K Coefficient: 3.6; K Coefficient Table: Regular 45, 90 and 180 Elbow; Loss Method: K Coefficient
Type - Pset_ManufacturerTypeInformation - Manufacturer: REHAU
Classification: D2090800 (Uniformat)
Pset_DistributionFlowElementCommon - Reference: RAUTITAN_Corner_LX:RTI LX C DN; sets with these values: 2
Other - Family: RAUTITAN_Corner_LX; Family and Type: RAUTITAN_Corner_LX: RTI LX C DN; IsCustom: yes; Sleeve DN1: Sleeve : LX 7,4; Sleeve DN2: Sleeve : LX 7,4; Type: RTI LX C DN; Type Id: 767005
Constraints - Elevation from Level: 0 mm; Level: REHAU Starting view
Data - PID Check: 0 mm
Dimensions - Angle: 90 deg; Area: 0.00465431 m2; Volume: 0.0000321717 m3
Graphics - Use Annotation Scale: no
Identity Data - ETIM Class: EC003024; ETIM Group: EG015540; ETIM Name: Fitting with 2 connections; PID: -; Sorting: 0; Tender text: -
Mechanical - System Classification: Undefined
Phasing - Phase Created: New Construction
Insulation - Insulation Thickness: 0 mm
Name (RAUTITAN_Corner_LX:RTI LX C DN:...) | L1 (mm) | L2 (mm) | Di1 (mm) | DN1 (mm) = DN2 (mm) = Maximum Size (mm) = Minimum Size (mm) | Size = Overall Size | Description long | GTIN | Product Group | Product URL | Weight
884892 | 15 | 18 | 6.6 | 10 | 10 mmø-10 mmø | REHAU Elbow RAUTITAN LX 12 - 12, 90 degree | 4007360468903 | 1670 | https://oxomi.com/p/3000126/datasheet/-/11681421001 | 0.039
1440894 | 17.7 | 21 | 9.9 | 12 | 12 mmø-12 mmø | REHAU Elbow RAUTITAN LX +G 16 - 16, 90 degree | 4007360543167 | 1685 | https://oxomi.com/p/3000126/datasheet/-/13129851001 | 0.065

# IfcFlowFitting: RAUTITAN_Corner_LX:RTI LX/PX C DN (8)
In: REHAU Starting view
Type - Material: Br
Type - Other - Category: Pipe Fittings; Sleeve LX: Sleeve : LX 7,4; Family Name: RAUTITAN_Corner_LX; Max sleeve: 32 mm; Min sleeve: 12 mm; Sleeve PX: Sleeve : PX 7,4; T1: RTI Corner LX; T2: RTI Corner LX P1
Type - Constraints - Default Elevation: 0 mm
Type - Data - Language: Description en; Language Tender Text: Tender Text en; Region Check: Check DE; Region PID: PID DE; Region URL: Product URL DE; T3: Sleeve DN
Type - Identity Data - Assembly Code: D2090800; Classification Number: 23.60.30.11.14; Manufacturer: REHAU; Model: RAUTITAN; REHAU Info: 14.02.2024-420668-420668; Type Name: RTI LX/PX C DN
Type - Materials and Finishes - Mat. Error: Error; Mat. Fitting: Br
Type - Mechanical - K Coefficient: 3.6; Loss Method: K Coefficient; K Coefficient Table: Regular 45, 90 and 180 Elbow
Type - Pset_ManufacturerTypeInformation - Manufacturer: REHAU
Classification: D2090800 (Uniformat)
Pset_DistributionFlowElementCommon - Reference: RAUTITAN_Corner_LX:RTI LX/PX C DN; sets with these values: 2
Other - Family: RAUTITAN_Corner_LX; IsCustom: no; Family and Type: RAUTITAN_Corner_LX: RTI LX/PX C DN; Type: RTI LX/PX C DN; Type Id: 767007
Constraints - Elevation from Level: 0 mm; Level: REHAU Starting view
Data - PID Check: 1 mm
Dimensions - Area: 0.00465431 m2
Graphics - Use Annotation Scale: no
Identity Data - Sorting: 0; ETIM Class: EC003024; ETIM Group: EG015540; ETIM Name: Fitting with 2 connections; Tender text: -
Mechanical - System Classification: Undefined
Phasing - Phase Created: New Construction
Insulation - Insulation Thickness: 0 mm
Name (RAUTITAN_Corner_LX:RTI LX/PX C DN:...) | Sleeve DN1 = Sleeve DN2 | L1 (mm) | L2 (mm) | Angle (deg) | Di1 (mm) | DN1 (mm) = DN2 (mm) = Maximum Size (mm) = Minimum Size (mm) | Size = Overall Size | Volume (m3) | Description long | GTIN | PID | Product Group | Product URL | Weight
961602 | Sleeve : PX 7,4 | 19.7 | 23.5 | 90 | 12.5 | 15 | 15 mmø-15 mmø | 0.0000144354 | REHAU Elbow RAUTITAN LX +G 20 - 20, 90 degree | 4007360543174 | 13129861001 | 1686 | https://oxomi.com/p/3000126/datasheet/-/13129861001 | 0.1
961608 | Sleeve : PX 7,4 | 23.4 | 27.6 | 90 | 15.2 | 20 | 20 mmø-20 mmø | 0.000027148 | REHAU Elbow RAUTITAN LX +G 25 - 25, 90 degree | 4007360543181 | 13129871001 | 1689 | https://oxomi.com/p/3000126/datasheet/-/13129871001 | 0.16
961614 | Sleeve : PX 7,4 | 26.5 | 31.5 | 90 | 20 | 25 | 25 mmø-25 mmø | 0.0000378291 | REHAU Elbow RAUTITAN LX +G 32 - 32, 90 degree | 4007360543198 | 13129881001 | 1690 | https://oxomi.com/p/3000126/datasheet/-/13129881001 | 0.31
961620 | Sleeve : PX 7,4 | 33 | 40 | 90 | 23 | 32 | 32 mmø-32 mmø | 0.0000748314 | REHAU Elbow RAUTITAN LX +G 40 - 40, 90 degree | 4007360543204 | 13129891001 | 1691 | https://oxomi.com/p/3000126/datasheet/-/13129891001 | 0.59
986855 | Sleeve : LX 7,4 | 39 | 46 | 90 | 30 | 40 | 40 mmø-40 mmø | 0.000112783 | REHAU Elbow RAUTITAN LX 50 - 50, 90 degree | 4007360458768 | 11681531001 | 1675 | https://oxomi.com/p/3000126/datasheet/-/11681531001 | 0.96
986868 | Sleeve : LX 7,4 | 45.5 | 54 | 90 | 39 | 50 | 50 mmø-50 mmø | 0.000183732 | REHAU Elbow RAUTITAN LX 63 - 63, 90 degree | 4007360458720 | 11681551001 | 1676 | https://oxomi.com/p/3000126/datasheet/-/11681551001 | 1.4
986992 | Sleeve : LX 7,4 | 20.8 | 29.3 | 45 | 39 | 50 | 50 mmø-50 mmø | 0.000151105 | REHAU Elbow RAUTITAN LX 63 - 63, 45 degree | 4007360458713 | 11681541001 | 1668 | https://oxomi.com/p/3000126/datasheet/-/11681541001 | 1.27
986994 | Sleeve : LX 7,4 | 19 | 26 | 45 | 30 | 40 | 40 mmø-40 mmø | 0.0000917925 | REHAU Elbow RAUTITAN LX 50 - 50, 45 degree | 4007360458751 | 11681521001 | 1667 | https://oxomi.com/p/3000126/datasheet/-/11681521001 | 0.72

# IfcFlowFitting: RAUTITAN_Corner_LX:RTI LX/PX C DN (2)
In: REHAU Starting view
Type - Material: Error, Br
Type - Other - Category: Pipe Fittings; Sleeve LX: Sleeve : LX 7,4; Family Name: RAUTITAN_Corner_LX; Max sleeve: 32 mm; Min sleeve: 12 mm; Sleeve PX: Sleeve : PX 7,4; T1: RTI Corner LX; T2: RTI Corner LX P1
Type - Constraints - Default Elevation: 0 mm
Type - Data - Language: Description en; Language Tender Text: Tender Text en; Region Check: Check DE; Region PID: PID DE; Region URL: Product URL DE; T3: Sleeve DN
Type - Identity Data - Assembly Code: D2090800; Classification Number: 23.60.30.11.14; Manufacturer: REHAU; Model: RAUTITAN; REHAU Info: 14.02.2024-420668-420668; Type Name: RTI LX/PX C DN
Type - Materials and Finishes - Mat. Error: Error; Mat. Fitting: Br
Type - Mechanical - K Coefficient: 3.6; Loss Method: K Coefficient; K Coefficient Table: Regular 45, 90 and 180 Elbow
Type - Pset_ManufacturerTypeInformation - Manufacturer: REHAU
Classification: D2090800 (Uniformat)
Pset_DistributionFlowElementCommon - Reference: RAUTITAN_Corner_LX:RTI LX/PX C DN; sets with these values: 2
Other - Family: RAUTITAN_Corner_LX; IsCustom: yes; Family and Type: RAUTITAN_Corner_LX: RTI LX/PX C DN; Type: RTI LX/PX C DN; Type Id: 767007
Constraints - Elevation from Level: 0 mm; Level: REHAU Starting view
Data - PID Check: 0 mm
Dimensions - Angle: 90 deg; Area: 0.00465431 m2; Volume: 0.0000321717 m3
Graphics - Use Annotation Scale: no
Identity Data - Sorting: 0; ETIM Class: EC003024; ETIM Group: EG015540; ETIM Name: Fitting with 2 connections; PID: -; Tender text: -
Mechanical - System Classification: Undefined
Phasing - Phase Created: New Construction
Insulation - Insulation Thickness: 0 mm
Name (RAUTITAN_Corner_LX:RTI LX/PX C DN:...) | Sleeve DN1 = Sleeve DN2 | L1 (mm) | L2 (mm) | Di1 (mm) | DN1 (mm) = DN2 (mm) = Maximum Size (mm) = Minimum Size (mm) | Size = Overall Size | Description long | GTIN | Product Group | Product URL | Weight
961596 | Sleeve : PX 7,4 | 17.7 | 21 | 9.9 | 12 | 12 mmø-12 mmø | REHAU Elbow RAUTITAN LX +G 16 - 16, 90 degree | 4007360543167 | 1685 | https://oxomi.com/p/3000126/datasheet/-/13129851001 | 0.065
1441230 | Sleeve : LX 7,4 | 15 | 18 | 6.6 | 10 | 10 mmø-10 mmø | REHAU Elbow RAUTITAN LX 12 - 12, 90 degree | 4007360468903 | 1670 | https://oxomi.com/p/3000126/datasheet/-/11681421001 | 0.039

# IfcFlowFitting: RAUTITAN_Corner_PX:RTI PX C DN (9)
In: REHAU Starting view
Type - Material: PX
Type - Other - Category: Pipe Fittings; Family Name: RAUTITAN_Corner_PX; T1: RTI Corner PX; T2: RTI Corner PX P1
Type - Constraints - Default Elevation: 0 mm
Type - Data - Language: Description en; Language Tender Text: Tender Text en; Region Check: Check DE; Region PID: PID DE; Region URL: Product URL DE; T3: Sleeve DN
Type - Identity Data - Assembly Code: D2090800; Classification Number: 23.60.30.11.14; Manufacturer: REHAU; Model: RAUTITAN; REHAU Info: 14.02.2024-420668-420668; Type Name: RTI PX C DN
Type - Materials and Finishes - Mat. Fitting: PX
Type - Mechanical - K Coefficient: 3.6; Loss Method: K Coefficient; K Coefficient Table: Regular 45, 90 and 180 Elbow
Type - Pset_ManufacturerTypeInformation - Manufacturer: REHAU
Classification: D2090800 (Uniformat)
Pset_DistributionFlowElementCommon - Reference: RAUTITAN_Corner_PX:RTI PX C DN; sets with these values: 2
Other - IsCustom: no; Family: RAUTITAN_Corner_PX; Family and Type: RAUTITAN_Corner_PX: RTI PX C DN; Type: RTI PX C DN; Type Id: 769804
Constraints - Elevation from Level: 0 mm; Level: REHAU Starting view
Data - PID Check: 1 mm
Dimensions - Area: 0.00465431 m2
Graphics - Use Annotation Scale: no
Identity Data - Sorting: 0; ETIM Class: EC003024; ETIM Group: EG015540; ETIM Name: Fitting with 2 connections; Tender text: -
Mechanical - System Classification: Undefined
Phasing - Phase Created: New Construction
Insulation - Insulation Thickness: 0 mm
Name (RAUTITAN_Corner_PX:RTI PX C DN:...) | L1 (mm) | LS1 (mm) | Angle (deg) | Di1 (mm) | DN1 (mm) = Maximum Size (mm) = Minimum Size (mm) | Size = Overall Size | Volume (m3) | Description long | GTIN | PID | Product Group | Product URL | Weight
1078268 | 21 | 23.7 | 90 | 9 | 12 | 12 mmø-12 mmø | 0.00000909026 | REHAU Elbow RAUTITAN PX 16 - 16, 90 degree | 4007360366452 | 11600211001 | 1653 | https://oxomi.com/p/3000126/datasheet/-/11600211001 | 0.0117
1078270 | 22.5 | 25 | 90 | 11.2 | 15 | 15 mmø-15 mmø | 0.0000158241 | REHAU Elbow RAUTITAN PX 20 - 20, 90 degree | 4007360366469 | 11600221001 | 1654 | https://oxomi.com/p/3000126/datasheet/-/11600221001 | 0.0184
1078272 | 25 | 27.2 | 90 | 13.5 | 20 | 20 mmø-20 mmø | 0.00002449 | REHAU Elbow RAUTITAN PX 25 - 25, 90 degree | 4007360366476 | 11600231001 | 1655 | https://oxomi.com/p/3000126/datasheet/-/11600231001 | 0.0313
1078274 | 27.5 | 34 | 90 | 18.1 | 25 | 25 mmø-25 mmø | 0.0000431598 | REHAU Elbow RAUTITAN PX 32 - 32, 90 degree | 4007360366483 | 11600241001 | 1656 | https://oxomi.com/p/3000126/datasheet/-/11600241001 | 0.0555
1078276 | 31 | 37.8 | 90 | 22 | 32 | 32 mmø-32 mmø | 0.0000838716 | REHAU Elbow RAUTITAN PX 40 - 40, 90 degree | 4007360366490 | 11600251001 | 1657 | https://oxomi.com/p/3000126/datasheet/-/11600251001 | 0.1046
1078288 | 13.7132 | 25 | 45 | 11.2 | 15 | 15 mmø-15 mmø | 0.0000130836 | REHAU Elbow RAUTITAN PX 20 - 20, 45 degree | 4007360376918 | 11600521001 | 1642 | https://oxomi.com/p/3000126/datasheet/-/11600521001 | 0.0169
1078290 | 16.2132 | 27.2 | 45 | 13.5 | 20 | 20 mmø-20 mmø | 0.0000212051 | REHAU Elbow RAUTITAN PX 25 - 25, 45 degree | 4007360376925 | 11600531001 | 1643 | https://oxomi.com/p/3000126/datasheet/-/11600531001 | 0.0281
1078292 | 18.7132 | 34 | 45 | 18.1 | 25 | 25 mmø-25 mmø | 0.0000382794 | REHAU Elbow RAUTITAN PX 32 - 32, 45 degree | 4007360376932 | 11600541001 | 1644 | https://oxomi.com/p/3000126/datasheet/-/11600541001 | 0.0515
1078294 | 22.2132 | 37.8 | 45 | 22 | 32 | 32 mmø-32 mmø | 0.0000745967 | REHAU Elbow RAUTITAN PX 40 - 40, 45 degree | 4007360376949 | 11600551001 | 1645 | https://oxomi.com/p/3000126/datasheet/-/11600551001 | 0.0931

# IfcFlowFitting: RAUTITAN_Corner_RX+ stabil:RTI RX+ stabil C DN (4)
In: REHAU Starting view
Type - Material: RX
Type - Other - Category: Pipe Fittings; Family Name: RAUTITAN_Corner_RX+ stabil; T1: RTI Corner RX+ stabil; T2: RTI Corner RX+ stabil P1
Type - Constraints - Default Elevation: 0 mm
Type - Data - Language: Description en; Language Tender Text: Tender Text en; Region Check: Check DE; Region PID: PID DE; Region URL: Product URL DE; T3: Sleeve DN
Type - Identity Data - Assembly Code: D2090800; Classification Number: 23.60.30.11.14; Manufacturer: REHAU; Model: RAUTITAN; REHAU Info: 14.02.2024-420668-420668; Type Name: RTI RX+ stabil C DN
Type - Materials and Finishes - Mat. Fitting: RX
Type - Mechanical - Loss Method: K Coefficient; K Coefficient: 0.6; K Coefficient Table: Regular 45, 90 and 180 Elbow
Type - Pset_ManufacturerTypeInformation - Manufacturer: REHAU
Classification: D2090800 (Uniformat)
Pset_DistributionFlowElementCommon - Reference: RAUTITAN_Corner_RX+ stabil:RTI RX+ stabil C DN; sets with these values: 2
Other - IsCustom: no; Family: RAUTITAN_Corner_RX+ stabil; Family and Type: RAUTITAN_Corner_RX+ stabil: RTI RX+ stabil C DN; Type: RTI RX+ stabil C DN; Type Id: 772619
Constraints - Elevation from Level: 0 mm; Level: REHAU Starting view
Data - PID Check: 1 mm
Dimensions - Area: 0.00465431 m2
Graphics - Use Annotation Scale: no
Identity Data - Sorting: 0; ETIM Class: EC003024; ETIM Group: EG015540; ETIM Name: Fitting with 2 connections; Tender text: -
Mechanical - System Classification: Undefined
Phasing - Phase Created: New Construction
Insulation - Insulation Thickness: 0 mm
Name (RAUTITAN_Corner_RX+ stabil:RTI RX+ stabil C DN:...) | L1 (mm) | LS1 (mm) | R (mm) | Z1 (mm) | Z2 (mm) | Angle (deg) | Di1 (mm) | DN1 (mm) = Maximum Size (mm) = Minimum Size (mm) | Do1 (mm) | Size = Overall Size | Volume (m3) | Description long | GTIN | PID | Product Group | Product URL | Weight
1078278 | 39.5 | 45 | 11.8 | 32.55 | 32.55 | 90 | 33.5 | 40 | 41.5 | 40 mmø-40 mmø | 0.000102383 | REHAU Bend RAUTITAN RX+ stabil 50 - 50, 90 degree | 4062178676070 | 14600331001 | 1693 | https://oxomi.com/p/3000126/datasheet/-/14600331001 | 0.879
1078280 | 47.1 | 53 | 13.8 | 41.15 | 41.15 | 90 | 45.5 | 50 | 54.7 | 50 mmø-50 mmø | 0.000176815 | REHAU Bend RAUTITAN RX+ stabil 63 - 63, 90 degree | 4062178676087 | 14600341001 | 1694 | https://oxomi.com/p/3000126/datasheet/-/14600341001 | 1.475
1078284 | 21.5 | 53 | 10 | 15.4709 | 37.35 | 45 | 45.5 | 50 | 54.7 | 50 mmø-50 mmø | 0.00015137 | REHAU Bend RAUTITAN RX+ stabil 63 - 63, 45 degree | 4062178676063 | 14600321001 | 1697 | https://oxomi.com/p/3000126/datasheet/-/14600321001 | 1.256
1078286 | 19.5 | 45 | 11 | 13.1513 | 31.75 | 45 | 33.5 | 40 | 41.5 | 40 mmø-40 mmø | 0.000089473 | REHAU Bend RAUTITAN RX+ stabil 50 - 50, 45 degree | 4062178676056 | 14600311001 | 1696 | https://oxomi.com/p/3000126/datasheet/-/14600311001 | 0.762

# IfcFlowFitting: RAUTITAN_Corner_RX+:RTI RX+ C DN (8)
In: REHAU Starting view
Type - Material: RX
Type - Other - Category: Pipe Fittings; Family Name: RAUTITAN_Corner_RX+; Max Sleeve: 32 mm; Sleeve LX: Sleeve : LX 7,4; Sleeve PX: Sleeve : PX 7,4; T1: RTI Corner RX; T2: RTI Corner RX P1
Type - Constraints - Default Elevation: 0 mm
Type - Data - Language: Description en; Language Tender Text: Tender Text en; Region Check: Check DE; Region PID: PID DE; Region URL: Product URL DE; T3: Sleeve DN
Type - Identity Data - Assembly Code: D2090800; Classification Number: 23.60.30.11.14; Manufacturer: REHAU; Model: RAUTITAN; REHAU Info: 14.02.2024-420668-420668; Type Name: RTI RX+ C DN
Type - Materials and Finishes - Mat. Fitting: RX
Type - Mechanical - Loss Method: K Coefficient; K Coefficient: 0.6; K Coefficient Table: Regular 45, 90 and 180 Elbow
Type - Pset_ManufacturerTypeInformation - Manufacturer: REHAU
Classification: D2090800 (Uniformat)
Pset_DistributionFlowElementCommon - Reference: RAUTITAN_Corner_RX+:RTI RX+ C DN; sets with these values: 2
Other - IsCustom: no; Family: RAUTITAN_Corner_RX+; Family and Type: RAUTITAN_Corner_RX+: RTI RX+ C DN; Type: RTI RX+ C DN; Type Id: 775437
Constraints - Elevation from Level: 0 mm; Level: REHAU Starting view
Data - PID Check: 1 mm
Dimensions - Area: 0.00465431 m2
Graphics - Use Annotation Scale: no
Identity Data - Sorting: 0; ETIM Class: EC003024; ETIM Group: EG015540; ETIM Name: Fitting with 2 connections; Tender text: -
Mechanical - System Classification: Undefined
Phasing - Phase Created: New Construction
Insulation - Insulation Thickness: 0 mm
Name (RAUTITAN_Corner_RX+:RTI RX+ C DN:...) | Sleeve DN1 = Sleeve DN2 | L1 (mm) | LS1 (mm) | R (mm) | Z1 (mm) | Z2 (mm) | Angle (deg) | Di1 (mm) | DN1 (mm) = Maximum Size (mm) = Minimum Size (mm) | Do1 (mm) | Size = Overall Size | Volume (m3) | Description long | GTIN | PID | Product Group | Product URL | Weight
1078409 | Sleeve : PX 7,4 | 17.6 | 23.7 | 3.1 | 11.65 | 11.65 | 90 | 9.9 | 12 | 17.1 | 12 mmø-12 mmø | 0.00000884644 | REHAU Bend RAUTITAN RX+ 16 - 16, 90 degree | 4061264398438 | 14564291001 | 1678 | https://oxomi.com/p/3000126/datasheet/-/14564291001 | 0.067
1078411 | Sleeve : PX 7,4 | 19.6 | 25 | 6.1 | 16.15 | 16.15 | 90 | 12.5 | 15 | 20.1 | 15 mmø-15 mmø | 0.0000130478 | REHAU Bend RAUTITAN RX+ 20 - 20, 90 degree | 4061264398445 | 14564301001 | 1679 | https://oxomi.com/p/3000126/datasheet/-/14564301001 | 0.095
1078413 | Sleeve : PX 7,4 | 23.3 | 27.2 | 6.4 | 18.9 | 18.9 | 90 | 15.2 | 20 | 25 | 20 mmø-20 mmø | 0.0000245764 | REHAU Bend RAUTITAN RX+ 25 - 25, 90 degree | 4061264398452 | 14564311001 | 1680 | https://oxomi.com/p/3000126/datasheet/-/14564311001 | 0.163
1078415 | Sleeve : PX 7,4 | 26.4 | 34 | 9.4 | 23.4 | 23.4 | 90 | 20 | 25 | 28 | 25 mmø-25 mmø | 0.0000352509 | REHAU Bend RAUTITAN RX+ 32 - 32, 90 degree | 4061264398469 | 14564321001 | 1681 | https://oxomi.com/p/3000126/datasheet/-/14564321001 | 0.268
1078417 | Sleeve : LX 7,4 | 39.2 | 45 | 12 | 32.5 | 32.5 | 90 | 30.5 | 40 | 41 | 40 mmø-40 mmø | 0.000108634 | REHAU Bend RAUTITAN RX+ 50 - 50, 90 degree | 4061264397219 | 14563071001 | 1682 | https://oxomi.com/p/3000126/datasheet/-/14563071001 | 0.854
1078419 | Sleeve : LX 7,4 | 47.7 | 53 | 16 | 41 | 41 | 90 | 39.5 | 50 | 50 | 50 mmø-50 mmø | 0.00017904 | REHAU Bend RAUTITAN RX+ 63 - 63, 90 degree | 4061264397226 | 14563081001 | 1683 | https://oxomi.com/p/3000126/datasheet/-/14563081001 | 1.365
1078423 | Sleeve : LX 7,4 | 21.5 | 53 | 8 | 13.669 | 33 | 45 | 39.5 | 50 | 50 | 50 mmø-50 mmø | 0.00015202 | REHAU Bend RAUTITAN RX+ 63 - 63, 45 degree | 4061264397240 | 14563101001 | 1651 | https://oxomi.com/p/3000126/datasheet/-/14563101001 | 1.193
1078425 | Sleeve : LX 7,4 | 19.4 | 45 | 6 | 10.9767 | 26.5 | 45 | 30.5 | 40 | 41 | 40 mmø-40 mmø | 0.0000926646 | REHAU Bend RAUTITAN RX+ 50 - 50, 45 degree | 4061264397233 | 14563091001 | 1650 | https://oxomi.com/p/3000126/datasheet/-/14563091001 | 0.725

# IfcFlowFitting: RAUTITAN_LX_C.Coupling:RTI LX/PX C.C DN (4)
In: REHAU Starting view
Type - Material: Br, Error
Type - Other - Category: Pipe Fittings; Family Name: RAUTITAN_LX_C.Coupling; T1: RTI C.Coupling; T2: Sleeve DN
Type - Constraints - Default Elevation: 0 mm
Type - Data - Language: Description en; Language Tender Text: Tender Text nl; Region Check: Check DE; Region PID: PID DE; Region URL: Product URL NL
Type - Identity Data - Assembly Code: D2090800; Classification Number: 23.60.30.11.14; Manufacturer: REHAU; Model: RAUTITAN; REHAU Info: 14.02.2024-420668-420668; Type Name: RTI LX/PX C.C DN
Type - Materials and Finishes - Mat. LX: Br
Type - Mechanical - Loss Method: K Coefficient; K Coefficient: 0.6; K Coefficient Table: Reducer/Coupling/Union/Increaser
Type - Pset_ManufacturerTypeInformation - Manufacturer: REHAU
Classification: D2090800 (Uniformat)
Pset_DistributionFlowElementCommon - Reference: RAUTITAN_LX_C.Coupling:RTI LX/PX C.C DN; sets with these values: 2
Other - IsCustom: yes; Family: RAUTITAN_LX_C.Coupling; Family and Type: RAUTITAN_LX_C.Coupling: RTI LX/PX C.C DN; Type: RTI LX/PX C.C DN; Type Id: 999821
Constraints - Elevation from Level: 0 mm; Level: REHAU Starting view
Data - PID Check: 0 mm
Graphics - Use Annotation Scale: no
Identity Data - Sorting: 0; ETIM Class: EC003024; ETIM Group: EG015540; ETIM Name: Fitting with 2 connections; PID: -; Tender text: -
Mechanical - System Classification: Undefined
Phasing - Phase Created: New Construction
Insulation - Insulation Thickness: 0 mm
Name (RAUTITAN_LX_C.Coupling:RTI LX/PX C.C DN:...) | L.8 (mm) | L.9 (mm) | Segmentation (deg) | Area (m2) | Di1 (mm) | DN1 (mm) = Minimum Size (mm) | DN2 (mm) = Maximum Size (mm) | Size = Overall Size | Volume (m3) | Description long | GTIN | Product Group | Product URL | Weight
1078154 | 5 | 14.3 | 60 | 0.00877517 | 9.9 | 12 | 15 | 15 mmø-12 mmø | 0.0000440591 | Crim.adaptor 16-Cu15 RAUT.LX+G | 4007360542757 | 1559 | https://oxomi.com/p/3001042/datasheet/-/13140991001 | 0.08
1078158 | 5 | 14.3 | 60 | 0.00923904 | 12.5 | 15 | 15 | 15 mmø-15 mmø | 0.0000455856 | Crim.adaptor 20-Cu15 RAUT.LX+G | 4007360542764 | 1560 | https://oxomi.com/p/3001042/datasheet/-/13141091001 | 0.086
1078561 | 6.5 | 16.3 | 45 | 0.0105787 | 12.5 | 15 | 22 | 22 mmø-15 mmø | 0.000050644 | Crim.adaptor 20-Cu15 RAUT.LX+G | 4007360542764 | 1560 | https://oxomi.com/p/3001042/datasheet/-/13141091001 | 0.086
1078565 | 6.5 | 16.3 | 45 | 0.0114373 | 15.2 | 20 | 22 | 22 mmø-20 mmø | 0.0000538481 | REHAU Crim. adaptor RAUTITAN LX +G 25 - Cu 22 | 4007360543501 | 1562 | https://oxomi.com/p/3001042/datasheet/-/13130781001 | 0.165

# IfcFlowFitting: RAUTITAN_Radiator TAG16:RAUTITAN_Radiator TAG16, RAUTITAN_Radiator TAG16:RAUTITAN_Radiator TAG16:1087027
In: REHAU Starting view
Type - Material: Stainless steel
Type - Other - Category: Pipe Fittings; Family Name: RAUTITAN_Radiator TAG16; T1: RTI_Radiator TAG16
Type - Constraints - Default Elevation: 0 mm
Type - Data - Language: Description EN; Region Check: Check DE; Region PID: PID DE
Type - Identity Data - Manufacturer: REHAU; Model: RAUTITAN; Type Name: RAUTITAN_Radiator TAG16
Type - Pset_ManufacturerTypeInformation - Manufacturer: REHAU
Pset_DistributionFlowElementCommon - Reference: RAUTITAN_Radiator TAG16:RAUTITAN_Radiator TAG16; sets with these values: 2
Other - IsCustom: no; Family: RAUTITAN_Radiator TAG16; Family and Type: RAUTITAN_Radiator TAG16: RAUTITAN_Radiator TAG16; Height product: 250 mm; Type: RAUTITAN_Radiator TAG16; Type Id: 1089423
Constraints - Elevation from Level: 0 mm; Level: REHAU Starting view; Moves With Nearby Elements: no
Data - PID Check: 1 mm
Dimensions - Area: 0.0141243 m2; Height: 200 mm; Volume: 0.0000218427 m3
Identity Data - Description long: REHAU Radiator connecting tee RAUTITAN 16 / 250 mm; GTIN: 4007360068042; PID: 12662821001; Weight: 187
Phasing - Phase Created: New Construction
Insulation - Insulation Thickness: 0 mm

# IfcFlowFitting: RAUTITAN_Radiator TAG20:RAUTITAN_Radiator TAG20, RAUTITAN_Radiator TAG20:RAUTITAN_Radiator TAG20:1087029
In: REHAU Starting view
Type - Material: Stainless steel
Type - Other - Category: Pipe Fittings; Family Name: RAUTITAN_Radiator TAG20; T1: RTI_Radiator TAG20
Type - Constraints - Default Elevation: 0 mm
Type - Data - Language: Description EN; Region Check: Check DE; Region PID: PID DE
Type - Identity Data - Type Name: RAUTITAN_Radiator TAG20
Pset_DistributionFlowElementCommon - Reference: RAUTITAN_Radiator TAG20:RAUTITAN_Radiator TAG20; sets with these values: 2
Other - IsCustom: no; Family: RAUTITAN_Radiator TAG20; Family and Type: RAUTITAN_Radiator TAG20: RAUTITAN_Radiator TAG20; Height product: 250 mm; Type: RAUTITAN_Radiator TAG20; Type Id: 1089425
Constraints - Elevation from Level: 0 mm; Level: REHAU Starting view; Moves With Nearby Elements: no
Data - PID Check: 1 mm
Dimensions - Area: 0.0152334 m2; Height: 200 mm; Volume: 0.0000261819 m3
Identity Data - Description long: REHAU Radiator connecting tee RAUTITAN 20 / 250 mm; GTIN: 4007360068066; PID: 12663021001; Weight: 222
Phasing - Phase Created: New Construction
Insulation - Insulation Thickness: 0 mm

# IfcFlowFitting: RAUTITAN_Radiator WAG16 Brass:RAUTITAN_Radiator WAG16 Brass, RAUTITAN_Radiator WAG16 Brass:RAUTITAN_Radiator WAG16 Brass:1087031
In: REHAU Starting view
Type - Material: Brass
Type - Other - Category: Pipe Fittings; Family Name: RAUTITAN_Radiator WAG16 Brass; T1: RTI_Radiator WAG16 Brass
Type - Constraints - Default Elevation: 0 mm
Type - Data - Language: Description EN; Region Check: Check DE; Region PID: PID DE
Type - Identity Data - Type Name: RAUTITAN_Radiator WAG16 Brass
Pset_DistributionFlowElementCommon - Reference: RAUTITAN_Radiator WAG16 Brass:RAUTITAN_Radiator WAG16 Brass; sets with these values: 2
Other - IsCustom: no; Family: RAUTITAN_Radiator WAG16 Brass; Family and Type: RAUTITAN_Radiator WAG16 Brass: RAUTITAN_Radiator WAG16 Brass; Height product: 250 mm; Type: RAUTITAN_Radiator WAG16 Brass; Type Id: 1089427
Constraints - Elevation from Level: 0 mm; Level: REHAU Starting view; Moves With Nearby Elements: no
Data - PID Check: 1 mm
Dimensions - Area: 0.0132459 m2; Height: 200 mm; Volume: 0.0000162473 m3
Identity Data - Description long: REHAU Cu/Brass Connecting bend set RAUT. nat. 16/250 mm incl. floor fixg. bracket; GTIN: 4007360160104; PID: 12664121001; Weight: 432
Phasing - Phase Created: New Construction
Insulation - Insulation Thickness: 0 mm

# IfcFlowFitting: RAUTITAN_Radiator WAG16:RAUTITAN_Radiator WAG16, RAUTITAN_Radiator WAG16:RAUTITAN_Radiator WAG16:1087033
In: REHAU Starting view
Type - Material: Stainless steel
Type - Other - Category: Pipe Fittings; Family Name: RAUTITAN_Radiator WAG16; T1: RTI_Radiator WAG16
Type - Constraints - Default Elevation: 0 mm
Type - Data - Language: Description EN; Region Check: Check DE; Region PID: PID DE
Type - Identity Data - Manufacturer: REHAU; Model: RAUTITAN; Type Name: RAUTITAN_Radiator WAG16
Type - Pset_ManufacturerTypeInformation - Manufacturer: REHAU
Pset_DistributionFlowElementCommon - Reference: RAUTITAN_Radiator WAG16:RAUTITAN_Radiator WAG16; sets with these values: 2
Other - IsCustom: no; Family: RAUTITAN_Radiator WAG16; Family and Type: RAUTITAN_Radiator WAG16: RAUTITAN_Radiator WAG16; Height product: 250 mm; Type: RAUTITAN_Radiator WAG16; Type Id: 1089429
Constraints - Elevation from Level: 0 mm; Level: REHAU Starting view; Moves With Nearby Elements: no
Data - PID Check: 1 mm
Dimensions - Area: 0.0120097 m2; Height: 200 mm; Volume: 0.0000125611 m3
Identity Data - Description long: REHAU Radiator connecting bend RAUTITAN 16 / 250 mm; GTIN: 4007360068004; PID: 12662421001; Weight: 128
Phasing - Phase Created: New Construction
Insulation - Insulation Thickness: 0 mm

# IfcFlowFitting: RAUTITAN_Radiator WAG20:RAUTITAN_Radiator WAG20, RAUTITAN_Radiator WAG20:RAUTITAN_Radiator WAG20:1087035
In: REHAU Starting view
Type - Material: Stainless steel
Type - Other - Category: Pipe Fittings; Family Name: RAUTITAN_Radiator WAG20; T1: RTI_Radiator WAG20
Type - Constraints - Default Elevation: 0 mm
Type - Data - Language: Description EN; Region Check: Check DE; Region PID: PID DE
Type - Identity Data - Manufacturer: REHAU; Model: RAUTITAN; Type Name: RAUTITAN_Radiator WAG20
Type - Pset_ManufacturerTypeInformation - Manufacturer: REHAU
Pset_DistributionFlowElementCommon - Reference: RAUTITAN_Radiator WAG20:RAUTITAN_Radiator WAG20; sets with these values: 2
Other - IsCustom: no; Family: RAUTITAN_Radiator WAG20; Family and Type: RAUTITAN_Radiator WAG20: RAUTITAN_Radiator WAG20; Height product: 250 mm; Type: RAUTITAN_Radiator WAG20; Type Id: 1089431
Constraints - Elevation from Level: 0 mm; Level: REHAU Starting view; Moves With Nearby Elements: no
Data - PID Check: 1 mm
Dimensions - Area: 0.0132068 m2; Height: 200 mm; Volume: 0.0000164999 m3
Identity Data - Description long: REHAU Radiator connecting bend RAUTITAN 20 / 250 mm; GTIN: 4007360068028; PID: 12662621001; Weight: 156
Phasing - Phase Created: New Construction
Insulation - Insulation Thickness: 0 mm

# IfcFlowFitting: RAUTITAN_Radiatorconnection box:RAUTITAN_Radiatorconnection box, RAUTITAN_Radiatorconnection box:RAUTITAN_Radiatorconnection box:1087037
In: REHAU Starting view
Type - Material: RAUTITAN PX, PU Hard Foam
Type - Other - Category: Pipe Fittings; Family Name: RAUTITAN_Radiatorconnection box; T1: RTI_Radiatorconnection box
Type - Constraints - Default Elevation: 0 mm
Type - Data - Language: Description EN; Region Check: Check DE; Region PID: PID DE
Type - Dimensions - Depth installation: 270 mm; Height installation: 540 mm
Type - Identity Data - Manufacturer: REHAU; Model: RAUTITAN; Type Name: RAUTITAN_Radiatorconnection box
Type - Pset_ManufacturerTypeInformation - Manufacturer: REHAU
Pset_DistributionFlowElementCommon - Reference: RAUTITAN_Radiatorconnection box:RAUTITAN_Radiatorconnection box; sets with these values: 2
Other - IsCustom: no; Family: RAUTITAN_Radiatorconnection box; Family and Type: RAUTITAN_Radiatorconnection box: RAUTITAN_Radiatorconnection box; Type: RAUTITAN_Radiatorconnection box; Type Id: 1089433
Constraints - Level: REHAU Starting view; Moves With Nearby Elements: no; Elevation from Level: -500 mm
Data - PID Check: 1 mm
Dimensions - Area: 0.085542 m2; Volume: 0.000858846 m3
Identity Data - Description long: REHAU Radiator connection block RAUTITAN stabil; GTIN: 4007360557287; PID: 11101981001; Weight: 220
Phasing - Phase Created: New Construction
Insulation - Insulation Thickness: 0 mm

# IfcFlowFitting: RAUTITAN_Sleeve PX2:RTI S PX 2 (14)
In: REHAU Starting view
Type - Material: RAUTITAN PX
Type - Other - Category: Pipe Fittings; Family Name: RAUTITAN_Sleeve PX2; T1: RTI Sleeve PX; T2: RTI Sleeve PX D
Type - Constraints - Default Elevation: 0 mm
Type - Identity Data - REHAU Info: 2024.06.11-420668-420668; Type Name: RTI S PX 2
Pset_DistributionFlowElementCommon - Reference: RAUTITAN_Sleeve PX2:RTI S PX 2; sets with these values: 2
Other - IsCustom: no; Family: RAUTITAN_Sleeve PX2; Family and Type: RAUTITAN_Sleeve PX2: RTI S PX 2; Type: RTI S PX 2; Type Id: 1089417
Constraints - Elevation from Level: 0 mm; Level: REHAU Starting view; Moves With Nearby Elements: no
Data - Language: Description EN; PID Check: 1 mm; Region Check: Check DE; Region PID: PID DE
Phasing - Phase Created: New Construction
Insulation - Insulation Thickness: 0 mm
Name (RAUTITAN_Sleeve PX2:RTI S PX 2:...) | Area (m2) | DN (mm) | L1 (mm) | Volume (m3) | Description long | GTIN | PID | Weight
1441766 | 0.0015541 | 12 | 23.7 | 0.00000312848 | REHAU Compression sleeve RAUTITAN PX 16 | 4007360361204 | 11600011001 | 7.6
1442980 | 0.0015541 | 12 | 23.7 | 0.00000312848 | REHAU Compression sleeve RAUTITAN PX 16 | 4007360361204 | 11600011001 | 7.6
1442982 | 0.00205237 | 15 | 25 | 0.00000516767 | REHAU Compression sleeve RAUTITAN PX 20 | 4007360361211 | 11600021001 | 11
