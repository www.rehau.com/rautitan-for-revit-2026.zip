Properties of the parts of a building model (IFC2X3), part 9 of 9

# IfcFlowSegment: Pipe Types:RAUTITAN Flex LX & RX+ Do (8)
Name (Pipe Types:RAUTITAN Flex LX & RX+ Do:...) | InvertElevation (mm) = Lower End Invert Elevation (mm) = Upper End Invert Elevation (mm) = Invert Elevation (mm) | Lower End Bottom Elevation (mm) = Upper End Bottom Elevation (mm) = Lower End Bottom of Insulation Elevation (mm) = Upper End Bottom of Insulation Elevation (mm) | Lower End Obvert Elevation (mm) = Upper End Obvert Elevation (mm) | Lower End Top Elevation (mm) = Upper End Top Elevation (mm) = Lower End Top of Insulation Elevation (mm) = Upper End Top of Insulation Elevation (mm) | Inside Diameter (mm) | Outside Diameter (mm) = Diameter (mm) | Size = Overall Size | Wall Thickness (mm) | Area (m2) | System Name = Group | Relative Roughness
1150860 | -7.2 | -10 | 7.2 | 10 | 14.4 | 20 | 20 mmø | 2.8 | 0.0628319 | Domestic Cold Water 40 | 0.000486111
1150862 | -9 | -12.5 | 9 | 12.5 | 18 | 25 | 25 mmø | 3.5 | 0.0785398 | Domestic Cold Water 41 | 0.000388889
1150864 | -11.6 | -16 | 11.6 | 16 | 23.2 | 32 | 32 mmø | 4.4 | 0.100531 | Domestic Cold Water 42 | 0.000301724
1150866 | -14.5 | -20 | 14.5 | 20 | 29 | 40 | 40 mmø | 5.5 | 0.125664 | Domestic Cold Water 43 | 0.000241379
1150868 | -18.1 | -25 | 18.1 | 25 | 36.2 | 50 | 50 mmø | 6.9 | 0.15708 | Domestic Cold Water 44 | 0.00019337
1151436 | -22.9 | -31.5 | 22.9 | 31.5 | 45.8 | 63 | 63 mmø | 8.6 | 0.19792 | Domestic Cold Water 39 | 0.000152838

# IfcFlowSegment: Pipe Types:RAUTITAN Flex PX & RX+ DN (7)
In: REHAU Starting view
Type - Other - Category: Pipes; Family Name: Pipe Types
Type - Identity Data - Assembly Code: 11303701100, 11303801100, 11303901050, 11304001050, 11304101006; Description: Drinking water & heating; Manufacturer: REHAU; Model: RAUTITAN; Type Comments: DN 12-32; Type Name: RAUTITAN Flex PX & RX+ DN; URL: www.rehau.com
Type - Pset_ManufacturerTypeInformation - Manufacturer: REHAU
Classification: 11303701100, 11303801100, 11303901050, 11304001050, 11304101006 (Uniformat)
Pset_DistributionFlowElementCommon - Reference: Pipe Types:RAUTITAN Flex PX & RX+ DN; sets with these values: 2
Pset_DuctConnection - ConnectionType: Generic; sets with these values: 2
Pset_FlowSegmentDuctSegment - Length: 1000 mm
Pset_FlowSegmentPipeSegment - Length: 1000 mm
Other - Family: Pipe Types; Family and Type: Pipe Types: RAUTITAN Flex PX & RX+ DN; Type: RAUTITAN Flex PX & RX+ DN; Type Id: 32134
Constraints - End Middle Elevation: 0 mm; Horizontal Justification: Center; Lower End Centerline Elevation: 0 mm; Middle Elevation: 0 mm; Reference Level: REHAU Starting view; Slope: 0; Start Middle Elevation: 0 mm; Upper End Centerline Elevation: 0 mm; Vertical Justification: Middle
Dimensions - Length: 1000 mm
Mechanical - System Type: Domestic Cold Water; Material: RAUTITAN flex; Pipe Segment: RAUTITAN flex - 10 - 50; Schedule/Type: 10 - 50; Connection Type: Generic; Roughness: 0.007 mm; System Classification: Domestic Cold Water
Mechanical - Flow - Additional Flow: 0 dm3/s; Fixture Units: 0; Flow: 0 dm3/s; Flow State: Laminar; Friction Factor: 0; Pressure Drop: 0 Pa; Reynolds Number: 0; Section: 1; Velocity: 0 m/s; Velocity Pressure: 0 Pa; Friction: 0 kg/m2/s2
Phasing - Phase Created: New Construction
Insulation - Insulation Thickness: 0 mm
Name (Pipe Types:RAUTITAN Flex PX & RX+ DN:...) | InvertElevation (mm) = Lower End Invert Elevation (mm) = Upper End Invert Elevation (mm) = Invert Elevation (mm) | Lower End Bottom Elevation (mm) = Upper End Bottom Elevation (mm) = Lower End Bottom of Insulation Elevation (mm) = Upper End Bottom of Insulation Elevation (mm) | Lower End Obvert Elevation (mm) = Upper End Obvert Elevation (mm) | Lower End Top Elevation (mm) = Upper End Top Elevation (mm) = Lower End Top of Insulation Elevation (mm) = Upper End Top of Insulation Elevation (mm) | Inside Diameter (mm) | Outside Diameter (mm) | Size = Overall Size | Wall Thickness (mm) | Area (m2) | Diameter (mm) | System Name = Group | Relative Roughness
1150500 | -5.8 | -8 | 5.8 | 8 | 11.6 | 16 | 12 mmø | 2.2 | 0.0376991 | 12 | Domestic Cold Water 24 | 0.000603448
1150502 | -7.2 | -10 | 7.2 | 10 | 14.4 | 20 | 15 mmø | 2.8 | 0.0471239 | 15 | Domestic Cold Water 25 | 0.000486111
1150504 | -9 | -12.5 | 9 | 12.5 | 18 | 25 | 20 mmø | 3.5 | 0.0628319 | 20 | Domestic Cold Water 26 | 0.000388889
1150506 | -11.6 | -16 | 11.6 | 16 | 23.2 | 32 | 25 mmø | 4.4 | 0.0785398 | 25 | Domestic Cold Water 27 | 0.000301724
1150508 | -14.5 | -20 | 14.5 | 20 | 29 | 40 | 32 mmø | 5.5 | 0.100531 | 32 | Domestic Cold Water 28 | 0.000241379
1150510 | -18.1 | -25 | 18.1 | 25 | 36.2 | 50 | 40 mmø | 6.9 | 0.125664 | 40 | Domestic Cold Water 29 | 0.00019337
1150512 | -22.9 | -31.5 | 22.9 | 31.5 | 45.8 | 63 | 50 mmø | 8.6 | 0.15708 | 50 | Domestic Cold Water 30 | 0.000152838

# IfcFlowSegment: Pipe Types:RAUTITAN Flex PX & RX+ Do (7)
In: REHAU Starting view
Type - Other - Category: Pipes; Family Name: Pipe Types
Type - Identity Data - Assembly Code: 11303701100, 11303801100, 11303901050, 11304001050, 11304101006; Description: Drinking water & heating; Manufacturer: REHAU; Model: RAUTITAN; Type Comments: Do 16-40; Type Name: RAUTITAN Flex PX & RX+ Do; URL: www.rehau.com
Type - Pset_ManufacturerTypeInformation - Manufacturer: REHAU
Classification: 11303701100, 11303801100, 11303901050, 11304001050, 11304101006 (Uniformat)
Pset_DistributionFlowElementCommon - Reference: Pipe Types:RAUTITAN Flex PX & RX+ Do; sets with these values: 2
Pset_DuctConnection - ConnectionType: Generic; sets with these values: 2
Pset_FlowSegmentDuctSegment - Length: 1000 mm
Pset_FlowSegmentPipeSegment - Length: 1000 mm
Other - Family: Pipe Types; Family and Type: Pipe Types: RAUTITAN Flex PX & RX+ Do; Type: RAUTITAN Flex PX & RX+ Do; Type Id: 854461
Constraints - End Middle Elevation: 0 mm; Horizontal Justification: Center; Lower End Centerline Elevation: 0 mm; Middle Elevation: 0 mm; Reference Level: REHAU Starting view; Slope: 0; Start Middle Elevation: 0 mm; Upper End Centerline Elevation: 0 mm; Vertical Justification: Middle
Dimensions - Length: 1000 mm
Mechanical - System Type: Domestic Cold Water; Material: RAUTITAN flex; Pipe Segment: RAUTITAN flex - Do 12 - 63; Schedule/Type: Do 12 - 63; Connection Type: Generic; Roughness: 0.007 mm; System Classification: Domestic Cold Water
Mechanical - Flow - Additional Flow: 0 dm3/s; Fixture Units: 0; Flow: 0 dm3/s; Flow State: Laminar; Friction Factor: 0; Pressure Drop: 0 Pa; Reynolds Number: 0; Section: 1; Velocity: 0 m/s; Velocity Pressure: 0 Pa; Friction: 0 kg/m2/s2
Phasing - Phase Created: New Construction
Insulation - Insulation Thickness: 0 mm
Name (Pipe Types:RAUTITAN Flex PX & RX+ Do:...) | InvertElevation (mm) = Lower End Invert Elevation (mm) = Upper End Invert Elevation (mm) = Invert Elevation (mm) | Lower End Bottom Elevation (mm) = Upper End Bottom Elevation (mm) = Lower End Bottom of Insulation Elevation (mm) = Upper End Bottom of Insulation Elevation (mm) | Lower End Obvert Elevation (mm) = Upper End Obvert Elevation (mm) | Lower End Top Elevation (mm) = Upper End Top Elevation (mm) = Lower End Top of Insulation Elevation (mm) = Upper End Top of Insulation Elevation (mm) | Inside Diameter (mm) | Outside Diameter (mm) = Diameter (mm) | Size = Overall Size | Wall Thickness (mm) | Area (m2) | System Name = Group | Relative Roughness
1151469 | -5.8 | -8 | 5.8 | 8 | 11.6 | 16 | 16 mmø | 2.2 | 0.0502655 | Domestic Cold Water 52 | 0.000603448
1151471 | -7.2 | -10 | 7.2 | 10 | 14.4 | 20 | 20 mmø | 2.8 | 0.0628319 | Domestic Cold Water 53 | 0.000486111
1151473 | -9 | -12.5 | 9 | 12.5 | 18 | 25 | 25 mmø | 3.5 | 0.0785398 | Domestic Cold Water 54 | 0.000388889
1151475 | -11.6 | -16 | 11.6 | 16 | 23.2 | 32 | 32 mmø | 4.4 | 0.100531 | Domestic Cold Water 55 | 0.000301724
1151477 | -14.5 | -20 | 14.5 | 20 | 29 | 40 | 40 mmø | 5.5 | 0.125664 | Domestic Cold Water 56 | 0.000241379
1151479 | -18.1 | -25 | 18.1 | 25 | 36.2 | 50 | 50 mmø | 6.9 | 0.15708 | Domestic Cold Water 57 | 0.00019337
1151481 | -22.9 | -31.5 | 22.9 | 31.5 | 45.8 | 63 | 63 mmø | 8.6 | 0.19792 | Domestic Cold Water 58 | 0.000152838

# IfcFlowSegment: Pipe Types:RAUTITAN Stabil LX & RX+ Stabil Do (7)
In: REHAU Starting view
Type - Other - Category: Pipes; Family Name: Pipe Types
Type - Identity Data - Assembly Code: 11300711005, 11301311100, 11301411050, 11301511025, 11301111005, 14601211005, 14601311005; Description: Drinking water & heating; Manufacturer: REHAU; Model: RAUTITAN; Type Comments: Do 16.2-63; Type Name: RAUTITAN Stabil LX & RX+ Stabil Do; URL: www.rehau.com
Type - Pset_ManufacturerTypeInformation - Manufacturer: REHAU
Classification: 11300711005, 11301311100, 11301411050, 11301511025, 11301111005, 14601211005, 14601311005 (Uniformat)
Pset_DistributionFlowElementCommon - Reference: Pipe Types:RAUTITAN Stabil LX & RX+ Stabil Do; sets with these values: 2
Pset_DuctConnection - ConnectionType: Generic; sets with these values: 2
Pset_FlowSegmentDuctSegment - Length: 1000 mm
Pset_FlowSegmentPipeSegment - Length: 1000 mm
Other - Family: Pipe Types; Family and Type: Pipe Types: RAUTITAN Stabil LX & RX+ Stabil Do; Type: RAUTITAN Stabil LX & RX+ Stabil Do; Type Id: 859655
Constraints - End Middle Elevation: 0 mm; Horizontal Justification: Center; Lower End Centerline Elevation: 0 mm; Middle Elevation: 0 mm; Reference Level: REHAU Starting view; Slope: 0; Start Middle Elevation: 0 mm; Upper End Centerline Elevation: 0 mm; Vertical Justification: Middle
Dimensions - Length: 1000 mm
Mechanical - Material: RAUTITAN stabil; System Type: Domestic Cold Water; Connection Type: Generic; Pipe Segment: RAUTITAN stabil - Do 16.2 - 63; Roughness: 0.007 mm; Schedule/Type: Do 16.2 - 63; System Classification: Domestic Cold Water
Mechanical - Flow - Additional Flow: 0 dm3/s; Fixture Units: 0; Flow: 0 dm3/s; Flow State: Laminar; Friction Factor: 0; Pressure Drop: 0 Pa; Reynolds Number: 0; Section: 1; Velocity: 0 m/s; Velocity Pressure: 0 Pa; Friction: 0 kg/m2/s2
Phasing - Phase Created: New Construction
Insulation - Insulation Thickness: 0 mm
Name (Pipe Types:RAUTITAN Stabil LX & RX+ Stabil Do:...) | InvertElevation (mm) = Lower End Invert Elevation (mm) = Upper End Invert Elevation (mm) = Invert Elevation (mm) | Lower End Bottom Elevation (mm) = Upper End Bottom Elevation (mm) = Lower End Bottom of Insulation Elevation (mm) = Upper End Bottom of Insulation Elevation (mm) | Lower End Obvert Elevation (mm) = Upper End Obvert Elevation (mm) | Lower End Top Elevation (mm) = Upper End Top Elevation (mm) = Lower End Top of Insulation Elevation (mm) = Upper End Top of Insulation Elevation (mm) | Inside Diameter (mm) | Outside Diameter (mm) | Size = Overall Size | Wall Thickness (mm) | Area (m2) | Diameter (mm) | System Name = Group | Relative Roughness
1150838 | -5.5 | -8.1 | 5.5 | 8.1 | 11 | 16.2 | 16 mmø | 2.6 | 0.0502655 | 16 | Domestic Cold Water 23 | 0.000636364
1150844 | -7.1 | -10 | 7.1 | 10 | 14.2 | 20 | 20 mmø | 2.9 | 0.0628319 | 20 | Domestic Cold Water 32 | 0.000492958
1150846 | -8.8 | -12.5 | 8.8 | 12.5 | 17.6 | 25 | 25 mmø | 3.7 | 0.0785398 | 25 | Domestic Cold Water 33 | 0.000397727
1150848 | -11.3 | -16 | 11.3 | 16 | 22.6 | 32 | 32 mmø | 4.7 | 0.100531 | 32 | Domestic Cold Water 34 | 0.000309735
1150850 | -14 | -20 | 14 | 20 | 28 | 40 | 40 mmø | 6 | 0.125664 | 40 | Domestic Cold Water 35 | 0.00025
1150852 | -20.5 | -25 | 20.5 | 25 | 41 | 50 | 50 mmø | 4.5 | 0.15708 | 50 | Domestic Cold Water 36 | 0.000170732
1151148 | -25.5 | -31.5 | 25.5 | 31.5 | 51 | 63 | 63 mmø | 6 | 0.19792 | 63 | Domestic Cold Water 37 | 0.000137255

# IfcFlowSegment: Pipe Types:RAUTITAN Stabil LX & RX+ stabil DN (7)
In: REHAU Starting view
Type - Other - Category: Pipes; Family Name: Pipe Types
Type - Identity Data - Assembly Code: 11300711005, 11301311100, 11301411050, 11301511025, 11301111005, 14601211005, 14601311005; Description: Drinking water & heating; Manufacturer: REHAU; Model: RAUTITAN; Type Comments: DN 12-50; Type Name: RAUTITAN Stabil LX & RX+ stabil DN; URL: www.rehau.com
Type - Pset_ManufacturerTypeInformation - Manufacturer: REHAU
Classification: 11300711005, 11301311100, 11301411050, 11301511025, 11301111005, 14601211005, 14601311005 (Uniformat)
Pset_DistributionFlowElementCommon - Reference: Pipe Types:RAUTITAN Stabil LX & RX+ stabil DN; sets with these values: 2
Pset_DuctConnection - ConnectionType: Generic; sets with these values: 2
Pset_FlowSegmentDuctSegment - Length: 1000 mm
Pset_FlowSegmentPipeSegment - Length: 1000 mm
Other - Family: Pipe Types; Family and Type: Pipe Types: RAUTITAN Stabil LX & RX+ stabil DN; Type: RAUTITAN Stabil LX & RX+ stabil DN; Type Id: 859342
Constraints - End Middle Elevation: 0 mm; Horizontal Justification: Center; Lower End Centerline Elevation: 0 mm; Middle Elevation: 0 mm; Reference Level: REHAU Starting view; Slope: 0; Start Middle Elevation: 0 mm; Upper End Centerline Elevation: 0 mm; Vertical Justification: Middle
Dimensions - Length: 1000 mm
Mechanical - Connection Type: Generic; Material: RAUTITAN stabil; Pipe Segment: RAUTITAN stabil - 12 - 50; Roughness: 0.007 mm; Schedule/Type: 12 - 50; System Classification: Domestic Cold Water; System Type: Domestic Cold Water
Mechanical - Flow - Additional Flow: 0 dm3/s; Fixture Units: 0; Flow: 0 dm3/s; Flow State: Laminar; Friction: 0 kg/m2/s2; Friction Factor: 0; Pressure Drop: 0 Pa; Reynolds Number: 0; Section: 1; Velocity: 0 m/s; Velocity Pressure: 0 Pa
Phasing - Phase Created: New Construction
Insulation - Insulation Thickness: 0 mm
Name (Pipe Types:RAUTITAN Stabil LX & RX+ stabil DN:...) | InvertElevation (mm) = Lower End Invert Elevation (mm) = Upper End Invert Elevation (mm) = Invert Elevation (mm) | Lower End Bottom Elevation (mm) = Upper End Bottom Elevation (mm) = Lower End Bottom of Insulation Elevation (mm) = Upper End Bottom of Insulation Elevation (mm) | Lower End Obvert Elevation (mm) = Upper End Obvert Elevation (mm) | Lower End Top Elevation (mm) = Upper End Top Elevation (mm) = Lower End Top of Insulation Elevation (mm) = Upper End Top of Insulation Elevation (mm) | Inside Diameter (mm) | Outside Diameter (mm) | Size = Overall Size | Wall Thickness (mm) | Area (m2) | Diameter (mm) | System Name = Group | Relative Roughness
1149273 | -5.5 | -8.1 | 5.5 | 8.1 | 11 | 16.2 | 12 mmø | 2.6 | 0.0376991 | 12 | Domestic Cold Water 1 | 0.000636364
1149556 | -7.1 | -10 | 7.1 | 10 | 14.2 | 20 | 15 mmø | 2.9 | 0.0471239 | 15 | Domestic Cold Water 3 | 0.000492958
1149576 | -8.8 | -12.5 | 8.8 | 12.5 | 17.6 | 25 | 20 mmø | 3.7 | 0.0628319 | 20 | Domestic Cold Water 4 | 0.000397727
1149581 | -14 | -20 | 14 | 20 | 28 | 40 | 32 mmø | 6 | 0.100531 | 32 | Domestic Cold Water 5 | 0.00025
1149586 | -20.5 | -25 | 20.5 | 25 | 41 | 50 | 40 mmø | 4.5 | 0.125664 | 40 | Domestic Cold Water 6 | 0.000170732
1149591 | -25.5 | -31.5 | 25.5 | 31.5 | 51 | 63 | 50 mmø | 6 | 0.15708 | 50 | Domestic Cold Water 7 | 0.000137255
1149905 | -11.3 | -16 | 11.3 | 16 | 22.6 | 32 | 25 mmø | 4.7 | 0.0785398 | 25 | Domestic Cold Water 8 | 0.000309735

# IfcFlowSegment: Pipe Types:RAUTITAN Stabil PX & RX+ Stabil DN (7)
In: REHAU Starting view
Type - Other - Category: Pipes; Family Name: Pipe Types
Type - Identity Data - Assembly Code: 11300711005, 11301311100, 11301411050, 11301511025, 11301111005, 14601211005, 14601311005; Description: Drinking water & heating; Manufacturer: REHAU; Model: RAUTITAN; Type Comments: DN 12-50; Type Name: RAUTITAN Stabil PX & RX+ Stabil DN; URL: www.rehau.com
Type - Pset_ManufacturerTypeInformation - Manufacturer: REHAU
Classification: 11300711005, 11301311100, 11301411050, 11301511025, 11301111005, 14601211005, 14601311005 (Uniformat)
Pset_DistributionFlowElementCommon - Reference: Pipe Types:RAUTITAN Stabil PX & RX+ Stabil DN; sets with these values: 2
Pset_DuctConnection - ConnectionType: Generic; sets with these values: 2
Pset_FlowSegmentDuctSegment - Length: 1000 mm
Pset_FlowSegmentPipeSegment - Length: 1000 mm
Other - Family: Pipe Types; Family and Type: Pipe Types: RAUTITAN Stabil PX & RX+ Stabil DN; Type: RAUTITAN Stabil PX & RX+ Stabil DN; Type Id: 32136
Constraints - End Middle Elevation: 0 mm; Horizontal Justification: Center; Lower End Centerline Elevation: 0 mm; Middle Elevation: 0 mm; Reference Level: REHAU Starting view; Slope: 0; Start Middle Elevation: 0 mm; Upper End Centerline Elevation: 0 mm; Vertical Justification: Middle
Dimensions - Length: 1000 mm
Mechanical - Material: RAUTITAN stabil; Pipe Segment: RAUTITAN stabil - 12 - 50; Schedule/Type: 12 - 50; System Type: Domestic Cold Water; Connection Type: Generic; Roughness: 0.007 mm; System Classification: Domestic Cold Water
Mechanical - Flow - Additional Flow: 0 dm3/s; Fixture Units: 0; Flow: 0 dm3/s; Flow State: Laminar; Friction Factor: 0; Pressure Drop: 0 Pa; Reynolds Number: 0; Section: 1; Velocity: 0 m/s; Velocity Pressure: 0 Pa; Friction: 0 kg/m2/s2
Phasing - Phase Created: New Construction
Insulation - Insulation Thickness: 0 mm
Name (Pipe Types:RAUTITAN Stabil PX & RX+ Stabil DN:...) | InvertElevation (mm) = Lower End Invert Elevation (mm) = Upper End Invert Elevation (mm) = Invert Elevation (mm) | Lower End Bottom Elevation (mm) = Upper End Bottom Elevation (mm) = Lower End Bottom of Insulation Elevation (mm) = Upper End Bottom of Insulation Elevation (mm) | Lower End Obvert Elevation (mm) = Upper End Obvert Elevation (mm) | Lower End Top Elevation (mm) = Upper End Top Elevation (mm) = Lower End Top of Insulation Elevation (mm) = Upper End Top of Insulation Elevation (mm) | Inside Diameter (mm) | Outside Diameter (mm) | Size = Overall Size | Wall Thickness (mm) | Area (m2) | Diameter (mm) | System Name = Group | Relative Roughness
1150371 | -5.5 | -8.1 | 5.5 | 8.1 | 11 | 16.2 | 12 mmø | 2.6 | 0.0376991 | 12 | Domestic Cold Water 16 | 0.000636364
1150374 | -7.1 | -10 | 7.1 | 10 | 14.2 | 20 | 15 mmø | 2.9 | 0.0471239 | 15 | Domestic Cold Water 17 | 0.000492958
1150376 | -8.8 | -12.5 | 8.8 | 12.5 | 17.6 | 25 | 20 mmø | 3.7 | 0.0628319 | 20 | Domestic Cold Water 18 | 0.000397727
1150378 | -14 | -20 | 14 | 20 | 28 | 40 | 32 mmø | 6 | 0.100531 | 32 | Domestic Cold Water 19 | 0.00025
1150380 | -20.5 | -25 | 20.5 | 25 | 41 | 50 | 40 mmø | 4.5 | 0.125664 | 40 | Domestic Cold Water 20 | 0.000170732
1150382 | -25.5 | -31.5 | 25.5 | 31.5 | 51 | 63 | 50 mmø | 6 | 0.15708 | 50 | Domestic Cold Water 21 | 0.000137255
1150384 | -11.3 | -16 | 11.3 | 16 | 22.6 | 32 | 25 mmø | 4.7 | 0.0785398 | 25 | Domestic Cold Water 22 | 0.000309735

# IfcFlowSegment: Pipe Types:RAUTITAN Stabil PX & RX+ Stabil Do (7)
In: REHAU Starting view
Type - Other - Category: Pipes; Family Name: Pipe Types
Type - Identity Data - Assembly Code: 11300711005, 11301311100, 11301411050, 11301511025, 11301111005, 14601211005, 14601311005; Description: Drinking water & heating; Manufacturer: REHAU; Model: RAUTITAN; Type Comments: Do 16.2-63; Type Name: RAUTITAN Stabil PX & RX+ Stabil Do; URL: www.rehau.com
Type - Pset_ManufacturerTypeInformation - Manufacturer: REHAU
Classification: 11300711005, 11301311100, 11301411050, 11301511025, 11301111005, 14601211005, 14601311005 (Uniformat)
Pset_DistributionFlowElementCommon - Reference: Pipe Types:RAUTITAN Stabil PX & RX+ Stabil Do; sets with these values: 2
Pset_DuctConnection - ConnectionType: Generic; sets with these values: 2
Pset_FlowSegmentDuctSegment - Length: 1000 mm
Pset_FlowSegmentPipeSegment - Length: 1000 mm
Other - Family: Pipe Types; Family and Type: Pipe Types: RAUTITAN Stabil PX & RX+ Stabil Do; Type: RAUTITAN Stabil PX & RX+ Stabil Do; Type Id: 680462
Constraints - End Middle Elevation: 0 mm; Horizontal Justification: Center; Lower End Centerline Elevation: 0 mm; Middle Elevation: 0 mm; Reference Level: REHAU Starting view; Slope: 0; Start Middle Elevation: 0 mm; Upper End Centerline Elevation: 0 mm; Vertical Justification: Middle
Dimensions - Length: 1000 mm
Mechanical - Material: RAUTITAN stabil; System Type: Domestic Cold Water; Pipe Segment: RAUTITAN stabil - Do 16.2 - 63; Schedule/Type: Do 16.2 - 63; Connection Type: Generic; Roughness: 0.007 mm; System Classification: Domestic Cold Water
Mechanical - Flow - Additional Flow: 0 dm3/s; Fixture Units: 0; Flow: 0 dm3/s; Flow State: Laminar; Friction Factor: 0; Pressure Drop: 0 Pa; Reynolds Number: 0; Section: 1; Velocity: 0 m/s; Velocity Pressure: 0 Pa; Friction: 0 kg/m2/s2
Phasing - Phase Created: New Construction
Insulation - Insulation Thickness: 0 mm
Name (Pipe Types:RAUTITAN Stabil PX & RX+ Stabil Do:...) | InvertElevation (mm) = Lower End Invert Elevation (mm) = Upper End Invert Elevation (mm) = Invert Elevation (mm) | Lower End Bottom Elevation (mm) = Upper End Bottom Elevation (mm) = Lower End Bottom of Insulation Elevation (mm) = Upper End Bottom of Insulation Elevation (mm) | Lower End Obvert Elevation (mm) = Upper End Obvert Elevation (mm) | Lower End Top Elevation (mm) = Upper End Top Elevation (mm) = Lower End Top of Insulation Elevation (mm) = Upper End Top of Insulation Elevation (mm) | Inside Diameter (mm) | Outside Diameter (mm) | Size = Overall Size | Wall Thickness (mm) | Area (m2) | Diameter (mm) | System Name = Group | Relative Roughness
1151185 | -5.5 | -8.1 | 5.5 | 8.1 | 11 | 16.2 | 16 mmø | 2.6 | 0.0502655 | 16 | Domestic Cold Water 45 | 0.000636364
1151187 | -7.1 | -10 | 7.1 | 10 | 14.2 | 20 | 20 mmø | 2.9 | 0.0628319 | 20 | Domestic Cold Water 46 | 0.000492958
1151189 | -8.8 | -12.5 | 8.8 | 12.5 | 17.6 | 25 | 25 mmø | 3.7 | 0.0785398 | 25 | Domestic Cold Water 47 | 0.000397727
1151191 | -11.3 | -16 | 11.3 | 16 | 22.6 | 32 | 32 mmø | 4.7 | 0.100531 | 32 | Domestic Cold Water 48 | 0.000309735
1151193 | -14 | -20 | 14 | 20 | 28 | 40 | 40 mmø | 6 | 0.125664 | 40 | Domestic Cold Water 49 | 0.00025
1151195 | -20.5 | -25 | 20.5 | 25 | 41 | 50 | 50 mmø | 4.5 | 0.15708 | 50 | Domestic Cold Water 50 | 0.000170732
1151197 | -25.5 | -31.5 | 25.5 | 31.5 | 51 | 63 | 63 mmø | 6 | 0.19792 | 63 | Domestic Cold Water 51 | 0.000137255

# IfcFlowSegment: Pipe Types:RAUTITAN flex LX & RX+ DN (8)
In: REHAU Starting view
Type - Other - Category: Pipes; Family Name: Pipe Types
Type - Identity Data - Assembly Code: 11303701100, 11303801100, 11303901050, 11304001050, 11304101006; Description: Drinking water & heating; Manufacturer: REHAU; Model: RAUTITAN; Type Comments: DN 12-32; Type Name: RAUTITAN flex LX & RX+ DN; URL: www.rehau.com
Type - Pset_ManufacturerTypeInformation - Manufacturer: REHAU
Classification: 11303701100, 11303801100, 11303901050, 11304001050, 11304101006 (Uniformat)
Pset_DistributionFlowElementCommon - Reference: Pipe Types:RAUTITAN flex LX & RX+ DN; sets with these values: 2
Pset_DuctConnection - ConnectionType: Generic; sets with these values: 2
Pset_FlowSegmentDuctSegment - Length: 1000 mm
Pset_FlowSegmentPipeSegment - Length: 1000 mm
Other - Family: Pipe Types; Family and Type: Pipe Types: RAUTITAN flex LX & RX+ DN; Type: RAUTITAN flex LX & RX+ DN; Type Id: 847740
Constraints - End Middle Elevation: 0 mm; Horizontal Justification: Center; Lower End Centerline Elevation: 0 mm; Middle Elevation: 0 mm; Reference Level: REHAU Starting view; Slope: 0; Start Middle Elevation: 0 mm; Upper End Centerline Elevation: 0 mm; Vertical Justification: Middle
Dimensions - Length: 1000 mm
Mechanical - System Type: Domestic Cold Water; Connection Type: Generic; Material: RAUTITAN flex; Pipe Segment: RAUTITAN flex - 10 - 50; Roughness: 0.007 mm; Schedule/Type: 10 - 50; System Classification: Domestic Cold Water
Mechanical - Flow - Additional Flow: 0 dm3/s; Fixture Units: 0; Flow: 0 dm3/s; Flow State: Laminar; Friction Factor: 0; Pressure Drop: 0 Pa; Reynolds Number: 0; Section: 1; Velocity: 0 m/s; Velocity Pressure: 0 Pa; Friction: 0 kg/m2/s2
Phasing - Phase Created: New Construction
Insulation - Insulation Thickness: 0 mm
Name (Pipe Types:RAUTITAN flex LX & RX+ DN:...) | InvertElevation (mm) = Lower End Invert Elevation (mm) = Upper End Invert Elevation (mm) = Invert Elevation (mm) | Lower End Bottom Elevation (mm) = Upper End Bottom Elevation (mm) = Lower End Bottom of Insulation Elevation (mm) = Upper End Bottom of Insulation Elevation (mm) | Lower End Obvert Elevation (mm) = Upper End Obvert Elevation (mm) | Lower End Top Elevation (mm) = Upper End Top Elevation (mm) = Lower End Top of Insulation Elevation (mm) = Upper End Top of Insulation Elevation (mm) | Inside Diameter (mm) | Outside Diameter (mm) | Size = Overall Size | Wall Thickness (mm) | Area (m2) | Diameter (mm) | System Name = Group | Relative Roughness
1149513 | -4.3 | -6 | 4.3 | 6 | 8.6 | 12 | 10 mmø | 1.7 | 0.0314159 | 10 | Domestic Cold Water 2 | 0.000813953
1149987 | -5.8 | -8 | 5.8 | 8 | 11.6 | 16 | 12 mmø | 2.2 | 0.0376991 | 12 | Domestic Cold Water 9 | 0.000603448
1150002 | -7.2 | -10 | 7.2 | 10 | 14.4 | 20 | 15 mmø | 2.8 | 0.0471239 | 15 | Domestic Cold Water 10 | 0.000486111
1150007 | -9 | -12.5 | 9 | 12.5 | 18 | 25 | 20 mmø | 3.5 | 0.0628319 | 20 | Domestic Cold Water 11 | 0.000388889
1150012 | -11.6 | -16 | 11.6 | 16 | 23.2 | 32 | 25 mmø | 4.4 | 0.0785398 | 25 | Domestic Cold Water 12 | 0.000301724
1150017 | -14.5 | -20 | 14.5 | 20 | 29 | 40 | 32 mmø | 5.5 | 0.100531 | 32 | Domestic Cold Water 13 | 0.000241379
1150022 | -18.1 | -25 | 18.1 | 25 | 36.2 | 50 | 40 mmø | 6.9 | 0.125664 | 40 | Domestic Cold Water 14 | 0.00019337
1150027 | -22.9 | -31.5 | 22.9 | 31.5 | 45.8 | 63 | 50 mmø | 8.6 | 0.15708 | 50 | Domestic Cold Water 15 | 0.000152838

# IfcFlowTerminal: RAUTITAN_Bath&Laundry Assembly Angle:12 Inch Angle, RAUTITAN_Bath&Laundry Assembly Angle:12 Inch Angle:1239654
In: REHAU Starting view
Type - Material: Brass, Copper
Type - Other - Category: Plumbing Fixtures; Connection Left: RAUTITAN_WM_Corner_RP_LX_AU : 12 RP 1/2 Left; Connection Right: RAUTITAN_WM_Corner_RP_LX_AU : 12 RP 1/2 Right; Family Name: RAUTITAN_Bath&Laundry Assembly Angle; MFT: Angle; T1: RTI BL Assembly
Type - Constraints - Default Elevation: 0 mm
Type - Data - Language: Description EN; Region Check: Check AU; Region PID: PID AU
Type - Dimensions - Width: 305 mm
Type - Identity Data - Manufacturer: REHAU; Model: RAUTITAN; REHAU Info: 2024.08.29-420668-420668; Type Name: 12 Inch Angle
Type - Pset_ManufacturerTypeInformation - Manufacturer: REHAU
Pset_DistributionFlowElementCommon - Reference: RAUTITAN_Bath&Laundry Assembly Angle:12 Inch Angle; sets with these values: 2
Other - IsCustom: no; Family: RAUTITAN_Bath&Laundry Assembly Angle; Family and Type: RAUTITAN_Bath&Laundry Assembly Angle: 12 Inch Angle; Type: 12 Inch Angle; Type Id: 1191303
Constraints - Elevation from Level: 0 mm; Level: REHAU Starting view; Offset from Host: 0 mm; Host: Level : REHAU Starting view
Data - PID Check: 1 mm
Dimensions - Area: 0.0178767 m2; DN: 12 mm; Volume: 0.0000426834 m3
Identity Data - Description long: RAUTITAN BATH/LNDRY ASMBLY R/A 12"; GTIN: 4007360479572; Mark: 25; PID: 268881-401; Weight: 0
Mechanical - System Classification: Domestic Cold Water,Domestic Hot Water
Phasing - Phase Created: New Construction

# IfcFlowTerminal: RAUTITAN_Bath&Laundry Assembly Angle:8 Inch Angle, RAUTITAN_Bath&Laundry Assembly Angle:8 Inch Angle:1239146
In: REHAU Starting view
Type - Material: Brass, Copper
Type - Other - Category: Plumbing Fixtures; Connection Left: RAUTITAN_WM_Corner_RP_LX_AU : 12 RP 1/2 Left; Connection Right: RAUTITAN_WM_Corner_RP_LX_AU : 12 RP 1/2 Right; Family Name: RAUTITAN_Bath&Laundry Assembly Angle; MFT: Angle; T1: RTI BL Assembly
Type - Constraints - Default Elevation: 0 mm
Type - Data - Language: Description EN; Region Check: Check AU; Region PID: PID AU
Type - Dimensions - Width: 205 mm
Type - Identity Data - Manufacturer: REHAU; Model: RAUTITAN; REHAU Info: 2024.08.29-420668-420668; Type Name: 8 Inch Angle
Type - Pset_ManufacturerTypeInformation - Manufacturer: REHAU
Pset_DistributionFlowElementCommon - Reference: RAUTITAN_Bath&Laundry Assembly Angle:8 Inch Angle; sets with these values: 2
Other - IsCustom: no; Type: 8 Inch Angle; Family: RAUTITAN_Bath&Laundry Assembly Angle; Family and Type: RAUTITAN_Bath&Laundry Assembly Angle: 8 Inch Angle; Type Id: 1191305
Constraints - Elevation from Level: 0 mm; Level: REHAU Starting view; Offset from Host: 0 mm; Host: Level : REHAU Starting view
Data - PID Check: 1 mm
Dimensions - Area: 0.0126303 m2; DN: 12 mm; Volume: 0.0000306171 m3
Identity Data - Description long: RAUTITAN BATH/LAUNDRY ASSEMBLY R/A 8"; GTIN: 4007360479534; Mark: 15; PID: 261955-401; Weight: 0
Mechanical - System Classification: Domestic Cold Water,Domestic Hot Water
Phasing - Phase Created: New Construction

# IfcFlowTerminal: RAUTITAN_Bath&Laundry Assembly Left straight:12 Inch Left straight, RAUTITAN_Bath&Laundry Assembly Left straight:12 Inch Left straight:1239526
In: REHAU Starting view
Type - Material: Brass, Copper
Type - Other - Category: Plumbing Fixtures; Connection Left: RAUTITAN_WM_Corner_RP_LX_AU : 12 RP 1/2 Straight Left; Connection Right: RAUTITAN_WM_Corner_RP_LX_AU : 12 RP 1/2 Right; Family Name: RAUTITAN_Bath&Laundry Assembly Left straight; MFT: Left Straight; T1: RTI BL Assembly
Type - Constraints - Default Elevation: 0 mm
Type - Data - Language: Description EN; Region Check: Check AU; Region PID: PID AU
Type - Dimensions - Width: 305 mm
Type - Identity Data - Manufacturer: REHAU; Model: RAUTITAN; REHAU Info: 2024.08.29-420668-420668; Type Name: 12 Inch Left straight
Type - Pset_ManufacturerTypeInformation - Manufacturer: REHAU
Pset_DistributionFlowElementCommon - Reference: RAUTITAN_Bath&Laundry Assembly Left straight:12 Inch Left straight; sets with these values: 2
Other - IsCustom: no; Family: RAUTITAN_Bath&Laundry Assembly Left straight; Family and Type: RAUTITAN_Bath&Laundry Assembly Left straight: 12 Inch Left straight; Type: 12 Inch Left straight; Type Id: 1196299
Constraints - Elevation from Level: 0 mm; Level: REHAU Starting view; Offset from Host: 0 mm; Host: Level : REHAU Starting view
Data - PID Check: 1 mm
Dimensions - Area: 0.0178767 m2; DN: 12 mm; Volume: 0.0000426834 m3
Identity Data - Description long: RAUTITAN BATH/LNDRY ASSEMBLY L.H STR 12"; GTIN: 4007360479473; Mark: 24; PID: 245987-401; Weight: 0
Mechanical - System Classification: Domestic Hot Water,Hydronic Supply
Phasing - Phase Created: New Construction

# IfcFlowTerminal: RAUTITAN_Bath&Laundry Assembly Rear:12 Inch Rear, RAUTITAN_Bath&Laundry Assembly Rear:12 Inch Rear:1239510
In: REHAU Starting view
Type - Material: Brass, Copper
Type - Other - Category: Plumbing Fixtures; Connection Left: RAUTITAN_WM_Corner_RP_LX_AU : 12 RP 1/2 Rear Left; Connection Right: RAUTITAN_WM_Corner_RP_LX_AU : 12 RP 1/2 Rear Right; Family Name: RAUTITAN_Bath&Laundry Assembly Rear; MFT: Rear; T1: RTI BL Assembly
Type - Constraints - Default Elevation: 0 mm
Type - Data - Language: Description EN; Region Check: Check AU; Region PID: PID AU
Type - Dimensions - Width: 305 mm
Type - Identity Data - Manufacturer: REHAU; Model: RAUTITAN; REHAU Info: 2024.08.29-420668-420668; Type Name: 12 Inch Rear
Type - Pset_ManufacturerTypeInformation - Manufacturer: REHAU
Pset_DistributionFlowElementCommon - Reference: RAUTITAN_Bath&Laundry Assembly Rear:12 Inch Rear; sets with these values: 2
Other - IsCustom: no; Family: RAUTITAN_Bath&Laundry Assembly Rear; Family and Type: RAUTITAN_Bath&Laundry Assembly Rear: 12 Inch Rear; Type: 12 Inch Rear; Type Id: 1201297
Constraints - Elevation from Level: 0 mm; Level: REHAU Starting view; Offset from Host: 0 mm; Host: Level : REHAU Starting view
Data - PID Check: 1 mm
Dimensions - Area: 0.0178767 m2; DN: 12 mm; Volume: 0.0000426834 m3
Identity Data - Description long: RAUTITAN BATH/LNDRY ASSEMBLY R-ENTRY 12"; GTIN: 4007360321352; Mark: 23; PID: 245997-001; Weight: 0
Mechanical - System Classification: Domestic Hot Water,Domestic Cold Water
Phasing - Phase Created: New Construction

# IfcFlowTerminal: RAUTITAN_Bath&Laundry Assembly Right straight:12 Inch Right straight, RAUTITAN_Bath&Laundry Assembly Right straight:12 Inch Right straight:1239436
In: REHAU Starting view
Type - Material: Brass, Copper
Type - Other - Category: Plumbing Fixtures; Connection Left: RAUTITAN_WM_Corner_RP_LX_AU : 12 RP 1/2 Left; Connection Right: RAUTITAN_WM_Corner_RP_LX_AU : 12 RP 1/2 Straight Right; Family Name: RAUTITAN_Bath&Laundry Assembly Right straight; MFT: Right Straight; T1: RTI BL Assembly
Type - Constraints - Default Elevation: 0 mm
Type - Data - Language: Description EN; Region Check: Check AU; Region PID: PID AU
Type - Dimensions - Width: 305 mm
Type - Identity Data - Manufacturer: REHAU; Model: RAUTITAN; REHAU Info: 2024.08.29-420668-420668; Type Name: 12 Inch Right straight
Type - Pset_ManufacturerTypeInformation - Manufacturer: REHAU
Pset_DistributionFlowElementCommon - Reference: RAUTITAN_Bath&Laundry Assembly Right straight:12 Inch Right straight; sets with these values: 2
Other - IsCustom: no; Family: RAUTITAN_Bath&Laundry Assembly Right straight; Family and Type: RAUTITAN_Bath&Laundry Assembly Right straight: 12 Inch Right straight; Type: 12 Inch Right straight; Type Id: 1206306
Constraints - Elevation from Level: 0 mm; Level: REHAU Starting view; Offset from Host: 0 mm; Host: Level : REHAU Starting view
Data - PID Check: 1 mm
Dimensions - Area: 0.0178767 m2; DN: 12 mm; Volume: 0.0000426834 m3
Identity Data - Description long: RAUTITAN BATH/LNDRY ASSEMBLY R.H STR 12"; GTIN: 4007360479466; Mark: 22; PID: 245977-401; Weight: 0
Mechanical - System Classification: Domestic Hot Water,Domestic Cold Water
Phasing - Phase Created: New Construction

# IfcFlowTerminal: RAUTITAN_Bath&Laundry Assembly Straight:12 Inch Straight, RAUTITAN_Bath&Laundry Assembly Straight:12 Inch Straight:1239298
In: REHAU Starting view
Type - Material: Brass, Copper
Type - Other - Category: Plumbing Fixtures; Connection Left: RAUTITAN_WM_Corner_RP_LX_AU : 12 RP 1/2 Straight Left; Connection Right: RAUTITAN_WM_Corner_RP_LX_AU : 12 RP 1/2 Straight Right; Family Name: RAUTITAN_Bath&Laundry Assembly Straight; MFT: Straight; T1: RTI BL Assembly
Type - Constraints - Default Elevation: 0 mm
Type - Data - Language: Description EN; Region Check: Check AU; Region PID: PID AU
Type - Dimensions - Width: 305 mm
Type - Identity Data - Manufacturer: REHAU; Model: RAUTITAN; REHAU Info: 2024.08.26-420668-420668; Type Name: 12 Inch Straight
Type - Pset_ManufacturerTypeInformation - Manufacturer: REHAU
Pset_DistributionFlowElementCommon - Reference: RAUTITAN_Bath&Laundry Assembly Straight:12 Inch Straight; sets with these values: 2
Other - IsCustom: no; Family: RAUTITAN_Bath&Laundry Assembly Straight; Family and Type: RAUTITAN_Bath&Laundry Assembly Straight: 12 Inch Straight; Type: 12 Inch Straight; Type Id: 1211314
Constraints - Elevation from Level: 0 mm; Level: REHAU Starting view; Offset from Host: 0 mm; Host: Level : REHAU Starting view
Data - PID Check: 1 mm
Dimensions - Area: 0.0178767 m2; DN: 12 mm; Volume: 0.0000426834 m3
Identity Data - Description long: RAUTITAN BATH/LNDRY STR 12"; GTIN: 4007360479565; Mark: 21; PID: 268871-401; Weight: 0
Mechanical - System Classification: Domestic Cold Water,Domestic Hot Water
Phasing - Phase Created: New Construction

# IfcFlowTerminal: RAUTITAN_Bath&Laundry Assembly Straight:8 Inch Straight, RAUTITAN_Bath&Laundry Assembly Straight:8 Inch Straight:1239135
In: REHAU Starting view
Type - Material: Brass, Copper
Type - Other - Category: Plumbing Fixtures; Connection Left: RAUTITAN_WM_Corner_RP_LX_AU : 12 RP 1/2 Straight Left; Connection Right: RAUTITAN_WM_Corner_RP_LX_AU : 12 RP 1/2 Straight Right; Family Name: RAUTITAN_Bath&Laundry Assembly Straight; MFT: Straight; T1: RTI BL Assembly
Type - Constraints - Default Elevation: 0 mm
Type - Data - Language: Description EN; Region Check: Check AU; Region PID: PID AU
Type - Dimensions - Width: 205 mm
Type - Identity Data - Manufacturer: REHAU; Model: RAUTITAN; REHAU Info: 2024.08.29-420668-420668; Type Name: 8 Inch Straight
Type - Pset_ManufacturerTypeInformation - Manufacturer: REHAU
Pset_DistributionFlowElementCommon - Reference: RAUTITAN_Bath&Laundry Assembly Straight:8 Inch Straight; sets with these values: 2
Other - IsCustom: no; Family: RAUTITAN_Bath&Laundry Assembly Straight; Family and Type: RAUTITAN_Bath&Laundry Assembly Straight: 8 Inch Straight; Type: 8 Inch Straight; Type Id: 1211316
Constraints - Elevation from Level: 0 mm; Level: REHAU Starting view; Offset from Host: 0 mm; Host: Level : REHAU Starting view
Data - PID Check: 1 mm
Dimensions - Area: 0.0126303 m2; DN: 12 mm; Volume: 0.0000306171 m3
Identity Data - Description long: RAUTITAN BATH/LAUNDRY ASSEMBLY STR 8"; GTIN: 4007360479527; Mark: 14; PID: 261945-401; Weight: 0
Mechanical - System Classification: Domestic Cold Water,Domestic Hot Water
Phasing - Phase Created: New Construction

# IfcFlowTerminal: RAUTITAN_Shower Assembly Angle:6 Inch Angle, RAUTITAN_Shower Assembly Angle:6 Inch Angle:1238842
In: REHAU Starting view
Type - Material: Copper, Brass
Type - Other - Category: Plumbing Fixtures; Connection Left: RAUTITAN_WM_Corner_RP_LX_AU : 12 RP 1/2 Left; Connection Right: RAUTITAN_WM_Corner_RP_LX_AU : 12 RP 1/2 Right; Family Name: RAUTITAN_Shower Assembly Angle; MFT: Angle; T1: RTI S Assembly
Type - Constraints - Default Elevation: 0 mm
Type - Data - Language: Description EN; Region Check: Check AU; Region PID: PID AU
Type - Dimensions - Width: 150 mm
Type - Identity Data - Manufacturer: REHAU; Model: RAUTITAN; REHAU Info: 2024.08.29-420668-420668; Type Name: 6 Inch Angle
Type - Pset_ManufacturerTypeInformation - Manufacturer: REHAU
Pset_DistributionFlowElementCommon - Reference: RAUTITAN_Shower Assembly Angle:6 Inch Angle; sets with these values: 2
Other - IsCustom: no; Family: RAUTITAN_Shower Assembly Angle; Family and Type: RAUTITAN_Shower Assembly Angle: 6 Inch Angle; Type: 6 Inch Angle; Type Id: 1216661
Constraints - Elevation from Level: 0 mm; Level: REHAU Starting view; Offset from Host: 0 mm; Host: Level : REHAU Starting view
Data - PID Check: 1 mm
Dimensions - Area: 0.0086062 m2; DN: 12 mm; Volume: 0.000019553 m3
Identity Data - Description long: RAUTITAN SHOWER ASSEMBLY R/A 6"; GTIN: 4007360479589; Mark: 6; PID: 268891-401; Weight: 0
Mechanical - System Classification: Domestic Cold Water,Domestic Hot Water
Phasing - Phase Created: New Construction

# IfcFlowTerminal: RAUTITAN_Shower Assembly Angle:8 Inch Angle, RAUTITAN_Shower Assembly Angle:8 Inch Angle:1238964
In: REHAU Starting view
Type - Material: Copper, Brass
Type - Other - Category: Plumbing Fixtures; Connection Left: RAUTITAN_WM_Corner_RP_LX_AU : 12 RP 1/2 Left; Connection Right: RAUTITAN_WM_Corner_RP_LX_AU : 12 RP 1/2 Right; Family Name: RAUTITAN_Shower Assembly Angle; MFT: Angle; T1: RTI S Assembly
Type - Constraints - Default Elevation: 0 mm
Type - Data - Language: Description EN; Region Check: Check AU; Region PID: PID AU
Type - Dimensions - Width: 205 mm
Type - Identity Data - Manufacturer: REHAU; Model: RAUTITAN; REHAU Info: 2024.08.29-420668-420668; Type Name: 8 Inch Angle
Type - Pset_ManufacturerTypeInformation - Manufacturer: REHAU
Pset_DistributionFlowElementCommon - Reference: RAUTITAN_Shower Assembly Angle:8 Inch Angle; sets with these values: 2
Other - IsCustom: no; Family: RAUTITAN_Shower Assembly Angle; Family and Type: RAUTITAN_Shower Assembly Angle: 8 Inch Angle; Type: 8 Inch Angle; Type Id: 1216663
Constraints - Elevation from Level: 0 mm; Level: REHAU Starting view; Offset from Host: 0 mm; Host: Level : REHAU Starting view
Data - PID Check: 1 mm
Dimensions - Area: 0.0114917 m2; DN: 12 mm; Volume: 0.0000261897 m3
Identity Data - Description long: RAUTITAN SHOWER ASSEMBLY R/A 8"; GTIN: 4007360479541; Mark: 10; PID: 261965-401; Weight: 0
Mechanical - System Classification: Domestic Cold Water,Domestic Hot Water
Phasing - Phase Created: New Construction

# IfcFlowTerminal: RAUTITAN_Shower Assembly Left Straight:6 Inch Left straight, RAUTITAN_Shower Assembly Left Straight:6 Inch Left straight:1238596
In: REHAU Starting view
Type - Material: Copper, Brass
Type - Other - Category: Plumbing Fixtures; Connection Left: RAUTITAN_WM_Corner_RP_LX_AU : 12 RP 1/2 Straight Left; Connection Right: RAUTITAN_WM_Corner_RP_LX_AU : 12 RP 1/2 Right; Family Name: RAUTITAN_Shower Assembly Left Straight; MFT: Left Straight; T1: RTI S Assembly
Type - Constraints - Default Elevation: 0 mm
Type - Data - Language: Description EN; Region Check: Check AU; Region PID: PID AU
Type - Dimensions - Width: 150 mm
Type - Identity Data - Manufacturer: REHAU; Model: RAUTITAN; REHAU Info: 2024.08.29-420668-420668; Type Name: 6 Inch Left straight
Type - Pset_ManufacturerTypeInformation - Manufacturer: REHAU
Pset_DistributionFlowElementCommon - Reference: RAUTITAN_Shower Assembly Left Straight:6 Inch Left straight; sets with these values: 2
Other - IsCustom: no; Family: RAUTITAN_Shower Assembly Left Straight; Family and Type: RAUTITAN_Shower Assembly Left Straight: 6 Inch Left straight; Type: 6 Inch Left straight; Type Id: 1222006
Constraints - Elevation from Level: 0 mm; Level: REHAU Starting view; Offset from Host: 0 mm; Host: Level : REHAU Starting view
Data - PID Check: 1 mm
Dimensions - Area: 0.0086062 m2; DN: 12 mm; Volume: 0.000019553 m3
Identity Data - Description long: RAUTITAN SHOWER ASSEMBLY L.H STRAIGHT 6"; GTIN: 4007360479503; Mark: 4; PID: 246117-401; Weight: 0
Mechanical - System Classification: Domestic Cold Water,Domestic Hot Water
Phasing - Phase Created: New Construction

# IfcFlowTerminal: RAUTITAN_Shower Assembly Right Straight:6 Inch Right Straight, RAUTITAN_Shower Assembly Right Straight:6 Inch Right Straight:1238578
In: REHAU Starting view
Type - Material: Copper, Brass
Type - Other - Category: Plumbing Fixtures; Connection Left: RAUTITAN_WM_Corner_RP_LX_AU : 12 RP 1/2 Left; Connection Right: RAUTITAN_WM_Corner_RP_LX_AU : 12 RP 1/2 Straight Right; Family Name: RAUTITAN_Shower Assembly Right Straight; MFT: Right Straight; T1: RTI S Assembly
Type - Constraints - Default Elevation: 0 mm
Type - Data - Language: Description EN; Region Check: Check AU; Region PID: PID AU
Type - Dimensions - Width: 150 mm
Type - Identity Data - Manufacturer: REHAU; Model: RAUTITAN; REHAU Info: 2024.08.29-420668-420668; Type Name: 6 Inch Right Straight
Type - Pset_ManufacturerTypeInformation - Manufacturer: REHAU
Pset_DistributionFlowElementCommon - Reference: RAUTITAN_Shower Assembly Right Straight:6 Inch Right Straight; sets with these values: 2
Other - IsCustom: no; Family: RAUTITAN_Shower Assembly Right Straight; Family and Type: RAUTITAN_Shower Assembly Right Straight: 6 Inch Right Straight; Type: 6 Inch Right Straight; Type Id: 1227349
Constraints - Elevation from Level: 0 mm; Level: REHAU Starting view; Offset from Host: 0 mm; Host: Level : REHAU Starting view
Data - PID Check: 1 mm
Dimensions - Area: 0.0086062 m2; DN: 12 mm; Volume: 0.000019553 m3
Identity Data - Description long: RAUTITAN SHOWER ASSEMBLY R.H STRAIGHT 6"; GTIN: 4007360479510; Mark: 3; PID: 246127-401; Weight: 0
Mechanical - System Classification: Domestic Hot Water,Domestic Cold Water
Phasing - Phase Created: New Construction

# IfcFlowTerminal: RAUTITAN_Shower Assembly Straight:6 Inch Straight, RAUTITAN_Shower Assembly Straight:6 Inch Straight:1238318
In: REHAU Starting view
Type - Material: Copper, Brass
Type - Other - Category: Plumbing Fixtures; Connection Left: RAUTITAN_WM_Corner_RP_LX_AU : 12 RP 1/2 Straight Left; Connection Right: RAUTITAN_WM_Corner_RP_LX_AU : 12 RP 1/2 Straight Right; Family Name: RAUTITAN_Shower Assembly Straight; MFT: Straight; T1: RTI S Assembly
Type - Constraints - Default Elevation: 0 mm
Type - Data - Language: Description EN; Region Check: Check AU; Region PID: PID AU
Type - Dimensions - Width: 150 mm
Type - Identity Data - Manufacturer: REHAU; Model: RAUTITAN; REHAU Info: 2024.08.29-420668-420668; Type Name: 6 Inch Straight
Type - Pset_ManufacturerTypeInformation - Manufacturer: REHAU
Pset_DistributionFlowElementCommon - Reference: RAUTITAN_Shower Assembly Straight:6 Inch Straight; sets with these values: 2
Other - IsCustom: no; Family: RAUTITAN_Shower Assembly Straight; Family and Type: RAUTITAN_Shower Assembly Straight: 6 Inch Straight; Type: 6 Inch Straight; Type Id: 1232692
Constraints - Elevation from Level: 0 mm; Level: REHAU Starting view; Offset from Host: 0 mm; Host: Level : REHAU Starting view
Data - PID Check: 1 mm
Dimensions - Area: 0.0086062 m2; DN: 12 mm; Volume: 0.000019553 m3
Identity Data - Description long: RAUTITAN SHOWER ASSEMBLY STRAIGHT 6"; GTIN: 4007360479558; Mark: 2; PID: 261995-401; Weight: 0
Mechanical - System Classification: Domestic Cold Water,Domestic Hot Water
Phasing - Phase Created: New Construction

# IfcFlowTerminal: RAUTITAN_Shower Assembly Up:6 Inch Up, RAUTITAN_Shower Assembly Up:6 Inch Up:1238073
In: REHAU Starting view
Type - Material: Copper, Brass
Type - Other - Category: Plumbing Fixtures; Connection Left: RAUTITAN_WM_Corner_RP_LX_AU : 12 RP 1/2 Left; Connection Right: RAUTITAN_WM_Corner_RP_LX_AU : 12 RP 1/2 Right; Family Name: RAUTITAN_Shower Assembly Up; MFT: Up; T1: RTI S Assembly
Type - Constraints - Default Elevation: 0 mm
Type - Data - Language: Description EN; Region Check: Check AU; Region PID: PID AU
Type - Dimensions - Width: 150 mm
Type - Identity Data - Manufacturer: REHAU; Model: RAUTITAN; REHAU Info: 2024.08.29-420668-420668; Type Name: 6 Inch Up
Type - Pset_ManufacturerTypeInformation - Manufacturer: REHAU
Pset_DistributionFlowElementCommon - Reference: RAUTITAN_Shower Assembly Up:6 Inch Up; sets with these values: 2
Other - IsCustom: no; Family: RAUTITAN_Shower Assembly Up; Family and Type: RAUTITAN_Shower Assembly Up: 6 Inch Up; Type: 6 Inch Up; Type Id: 1238037
Constraints - Elevation from Level: 0 mm; Level: REHAU Starting view; Offset from Host: 0 mm; Host: Level : REHAU Starting view
Data - PID Check: 1 mm
Dimensions - Area: 0.0086062 m2; DN: 12 mm; Volume: 0.000019553 m3
Identity Data - Description long: RAUTITAN SHOWER ASSEMBLY B/U 6"; GTIN: 4007360479480; Mark: 1; PID: 246007-401; Weight: 0
Mechanical - System Classification: Domestic Cold Water,Domestic Hot Water
Phasing - Phase Created: New Construction

# IfcFlowTerminal: RAUTITAN_Shower Assembly Up:8 Inch Up, RAUTITAN_Shower Assembly Up:8 Inch Up:1238953
In: REHAU Starting view
Type - Material: Copper, Brass
Type - Other - Category: Plumbing Fixtures; Connection Left: RAUTITAN_WM_Corner_RP_LX_AU : 12 RP 1/2 Left; Connection Right: RAUTITAN_WM_Corner_RP_LX_AU : 12 RP 1/2 Right; Family Name: RAUTITAN_Shower Assembly Up; MFT: Up; T1: RTI S Assembly
Type - Constraints - Default Elevation: 0 mm
Type - Data - Language: Description EN; Region Check: Check AU; Region PID: PID AU
Type - Dimensions - Width: 205 mm
Type - Identity Data - Manufacturer: REHAU; Model: RAUTITAN; REHAU Info: 2024.08.29-420668-420668; Type Name: 8 Inch Up
Type - Pset_ManufacturerTypeInformation - Manufacturer: REHAU
Pset_DistributionFlowElementCommon - Reference: RAUTITAN_Shower Assembly Up:8 Inch Up; sets with these values: 2
Other - IsCustom: no; Family: RAUTITAN_Shower Assembly Up; Family and Type: RAUTITAN_Shower Assembly Up: 8 Inch Up; Type: 8 Inch Up; Type Id: 1238039
Constraints - Elevation from Level: 0 mm; Level: REHAU Starting view; Offset from Host: 0 mm; Host: Level : REHAU Starting view
Data - PID Check: 1 mm
Dimensions - Area: 0.0114917 m2; DN: 12 mm; Volume: 0.0000261897 m3
Identity Data - Description long: RAUTITAN SHOWER ASSEMBLY B/U 8"; GTIN: 4007360479459; Mark: 9; PID: 245967-401; Weight: 0
Mechanical - System Classification: Domestic Cold Water,Domestic Hot Water
Phasing - Phase Created: New Construction

# IfcOpeningElement: Opening (78)
In: REHAU Starting view
Pset_OpeningElementCommon - sets with these values: 2
Name | Description | Reference
Halter O 100:1 | REHAU Bracket O 100, for double connection | REHAU_RAUTITAN_Bracket O 100:REHAU_RAUTITAN_Bracket O 100
Halter O 100:2 | REHAU Bracket O 100, for double connection | REHAU_RAUTITAN_Bracket O 100:REHAU_RAUTITAN_Bracket O 100
Halter O 100:3 | REHAU Bracket O 100, for double connection | REHAU_RAUTITAN_Bracket O 100:REHAU_RAUTITAN_Bracket O 100
Halter O 100:4 | REHAU Bracket O 100, for double connection | REHAU_RAUTITAN_Bracket O 100:REHAU_RAUTITAN_Bracket O 100
Halter O 100:5 | REHAU Bracket O 100, for double connection | REHAU_RAUTITAN_Bracket O 100:REHAU_RAUTITAN_Bracket O 100
Halter O 100:6 | REHAU Bracket O 100, for double connection | REHAU_RAUTITAN_Bracket O 100:REHAU_RAUTITAN_Bracket O 100
Halter O 100:7 | REHAU Bracket O 100, for double connection | REHAU_RAUTITAN_Bracket O 100:REHAU_RAUTITAN_Bracket O 100
Halter O 100:8 | REHAU Bracket O 100, for double connection | REHAU_RAUTITAN_Bracket O 100:REHAU_RAUTITAN_Bracket O 100
Halter O 100:9 | REHAU Bracket O 100, for double connection | REHAU_RAUTITAN_Bracket O 100:REHAU_RAUTITAN_Bracket O 100
Halter O 100:10 | REHAU Bracket O 100, for double connection | REHAU_RAUTITAN_Bracket O 100:REHAU_RAUTITAN_Bracket O 100
Halter O 100:11 | REHAU Bracket O 100, for double connection | REHAU_RAUTITAN_Bracket O 100:REHAU_RAUTITAN_Bracket O 100
Halter O 100:12 | REHAU Bracket O 100, for double connection | REHAU_RAUTITAN_Bracket O 100:REHAU_RAUTITAN_Bracket O 100
Halter O 100:13 | REHAU Bracket O 100, for double connection | REHAU_RAUTITAN_Bracket O 100:REHAU_RAUTITAN_Bracket O 100
Halter O 100:14 | REHAU Bracket O 100, for double connection | REHAU_RAUTITAN_Bracket O 100:REHAU_RAUTITAN_Bracket O 100
Halter O 100:15 | REHAU Bracket O 100, for double connection | REHAU_RAUTITAN_Bracket O 100:REHAU_RAUTITAN_Bracket O 100
Halter O 100:16 | REHAU Bracket O 100, for double connection | REHAU_RAUTITAN_Bracket O 100:REHAU_RAUTITAN_Bracket O 100
Halter O 100:17 | REHAU Bracket O 100, for double connection | REHAU_RAUTITAN_Bracket O 100:REHAU_RAUTITAN_Bracket O 100
Halter O 100:18 | REHAU Bracket O 100, for double connection | REHAU_RAUTITAN_Bracket O 100:REHAU_RAUTITAN_Bracket O 100
Halter O 100:19 | REHAU Bracket O 100, for double connection | REHAU_RAUTITAN_Bracket O 100:REHAU_RAUTITAN_Bracket O 100
Halter O 100:20 | REHAU Bracket O 100, for double connection | REHAU_RAUTITAN_Bracket O 100:REHAU_RAUTITAN_Bracket O 100
Halter O 100:21 | REHAU Bracket O 100, for double connection | REHAU_RAUTITAN_Bracket O 100:REHAU_RAUTITAN_Bracket O 100
Halter O 100:22 | REHAU Bracket O 100, for double connection | REHAU_RAUTITAN_Bracket O 100:REHAU_RAUTITAN_Bracket O 100
Halter O 100:23 | REHAU Bracket O 100, for double connection | REHAU_RAUTITAN_Bracket O 100:REHAU_RAUTITAN_Bracket O 100
Halter O 100:24 | REHAU Bracket O 100, for double connection | REHAU_RAUTITAN_Bracket O 100:REHAU_RAUTITAN_Bracket O 100
Halter O 100:25 | REHAU Bracket O 100, for double connection | REHAU_RAUTITAN_Bracket O 100:REHAU_RAUTITAN_Bracket O 100
Halter O 100:26 | REHAU Bracket O 100, for double connection | REHAU_RAUTITAN_Bracket O 100:REHAU_RAUTITAN_Bracket O 100
Halter O 100:27 | REHAU Bracket O 100, for double connection | REHAU_RAUTITAN_Bracket O 100:REHAU_RAUTITAN_Bracket O 100
Halter O 100:28 | REHAU Bracket O 100, for double connection | REHAU_RAUTITAN_Bracket O 100:REHAU_RAUTITAN_Bracket O 100
Halter O 100:29 | REHAU Bracket O 100, for double connection | REHAU_RAUTITAN_Bracket O 100:REHAU_RAUTITAN_Bracket O 100
Halter O 100:30 | REHAU Bracket O 100, for double connection | REHAU_RAUTITAN_Bracket O 100:REHAU_RAUTITAN_Bracket O 100
Halter O 100:31 | REHAU Bracket O 100, for double connection | REHAU_RAUTITAN_Bracket O 100:REHAU_RAUTITAN_Bracket O 100
Halter O 100:32 | REHAU Bracket O 100, for double connection | REHAU_RAUTITAN_Bracket O 100:REHAU_RAUTITAN_Bracket O 100
Halter O 100:33 | REHAU Bracket O 100, for double connection | REHAU_RAUTITAN_Bracket O 100:REHAU_RAUTITAN_Bracket O 100
Halter O 75/150:1 | REHAU Bracket O 75/150, for double connection | REHAU_RAUTITAN_Bracket O 75 150:REHAU_RAUTITAN_Bracket O 75 150
Halter O 75/150:2 | REHAU Bracket O 75/150, for double connection | REHAU_RAUTITAN_Bracket O 75 150:REHAU_RAUTITAN_Bracket O 75 150
Halter O 75/150:3 | REHAU Bracket O 75/150, for double connection | REHAU_RAUTITAN_Bracket O 75 150:REHAU_RAUTITAN_Bracket O 75 150
Halter O 75/150:4 | REHAU Bracket O 75/150, for double connection | REHAU_RAUTITAN_Bracket O 75 150:REHAU_RAUTITAN_Bracket O 75 150
Halter O 75/150:5 | REHAU Bracket O 75/150, for double connection | REHAU_RAUTITAN_Bracket O 75 150:REHAU_RAUTITAN_Bracket O 75 150
Halter O 75/150:6 | REHAU Bracket O 75/150, for double connection | REHAU_RAUTITAN_Bracket O 75 150:REHAU_RAUTITAN_Bracket O 75 150
Halter O 75/150:7 | REHAU Bracket O 75/150, for double connection | REHAU_RAUTITAN_Bracket O 75 150:REHAU_RAUTITAN_Bracket O 75 150
Halter O 75/150:8 | REHAU Bracket O 75/150, for double connection | REHAU_RAUTITAN_Bracket O 75 150:REHAU_RAUTITAN_Bracket O 75 150
Halter O 75/150:9 | REHAU Bracket O 75/150, for double connection | REHAU_RAUTITAN_Bracket O 75 150:REHAU_RAUTITAN_Bracket O 75 150
Halter O 75/150:10 | REHAU Bracket O 75/150, for double connection | REHAU_RAUTITAN_Bracket O 75 150:REHAU_RAUTITAN_Bracket O 75 150
Halter O 75/150:11 | REHAU Bracket O 75/150, for double connection | REHAU_RAUTITAN_Bracket O 75 150:REHAU_RAUTITAN_Bracket O 75 150
Halter O 75/150:12 | REHAU Bracket O 75/150, for double connection | REHAU_RAUTITAN_Bracket O 75 150:REHAU_RAUTITAN_Bracket O 75 150
Halter O 75/150:13 | REHAU Bracket O 75/150, for double connection | REHAU_RAUTITAN_Bracket O 75 150:REHAU_RAUTITAN_Bracket O 75 150
Halter O 75/150:14 | REHAU Bracket O 75/150, for double connection | REHAU_RAUTITAN_Bracket O 75 150:REHAU_RAUTITAN_Bracket O 75 150
Halter O 75/150:15 | REHAU Bracket O 75/150, for double connection | REHAU_RAUTITAN_Bracket O 75 150:REHAU_RAUTITAN_Bracket O 75 150
Halter O 75/150:16 | REHAU Bracket O 75/150, for double connection | REHAU_RAUTITAN_Bracket O 75 150:REHAU_RAUTITAN_Bracket O 75 150
Halter O 75/150:17 | REHAU Bracket O 75/150, for double connection | REHAU_RAUTITAN_Bracket O 75 150:REHAU_RAUTITAN_Bracket O 75 150
Halter O 75/150:18 | REHAU Bracket O 75/150, for double connection | REHAU_RAUTITAN_Bracket O 75 150:REHAU_RAUTITAN_Bracket O 75 150
Halter O 75/150:19 | REHAU Bracket O 75/150, for double connection | REHAU_RAUTITAN_Bracket O 75 150:REHAU_RAUTITAN_Bracket O 75 150
Halter O 75/150:20 | REHAU Bracket O 75/150, for double connection | REHAU_RAUTITAN_Bracket O 75 150:REHAU_RAUTITAN_Bracket O 75 150
Halter O 75/150:21 | REHAU Bracket O 75/150, for double connection | REHAU_RAUTITAN_Bracket O 75 150:REHAU_RAUTITAN_Bracket O 75 150
Halter O 75/150:22 | REHAU Bracket O 75/150, for double connection | REHAU_RAUTITAN_Bracket O 75 150:REHAU_RAUTITAN_Bracket O 75 150
Halter O 75/150:23 | REHAU Bracket O 75/150, for double connection | REHAU_RAUTITAN_Bracket O 75 150:REHAU_RAUTITAN_Bracket O 75 150
Halter O 75/150:24 | REHAU Bracket O 75/150, for double connection | REHAU_RAUTITAN_Bracket O 75 150:REHAU_RAUTITAN_Bracket O 75 150
Halter O 75/150:25 | REHAU Bracket O 75/150, for double connection | REHAU_RAUTITAN_Bracket O 75 150:REHAU_RAUTITAN_Bracket O 75 150
Halter O 75/150:26 | REHAU Bracket O 75/150, for double connection | REHAU_RAUTITAN_Bracket O 75 150:REHAU_RAUTITAN_Bracket O 75 150
Halter O 75/150:27 | REHAU Bracket O 75/150, for double connection | REHAU_RAUTITAN_Bracket O 75 150:REHAU_RAUTITAN_Bracket O 75 150
Halter O 75/150:28 | REHAU Bracket O 75/150, for double connection | REHAU_RAUTITAN_Bracket O 75 150:REHAU_RAUTITAN_Bracket O 75 150
Halter O 75/150:29 | REHAU Bracket O 75/150, for double connection | REHAU_RAUTITAN_Bracket O 75 150:REHAU_RAUTITAN_Bracket O 75 150
Halter O 75/150:30 | REHAU Bracket O 75/150, for double connection | REHAU_RAUTITAN_Bracket O 75 150:REHAU_RAUTITAN_Bracket O 75 150
Halter O 75/150:31 | REHAU Bracket O 75/150, for double connection | REHAU_RAUTITAN_Bracket O 75 150:REHAU_RAUTITAN_Bracket O 75 150
Halter O 75/150:32 | REHAU Bracket O 75/150, for double connection | REHAU_RAUTITAN_Bracket O 75 150:REHAU_RAUTITAN_Bracket O 75 150
Halter O 75/150:33 | REHAU Bracket O 75/150, for double connection | REHAU_RAUTITAN_Bracket O 75 150:REHAU_RAUTITAN_Bracket O 75 150
Halter O 75/150:34 | REHAU Bracket O 75/150, for double connection | REHAU_RAUTITAN_Bracket O 75 150:REHAU_RAUTITAN_Bracket O 75 150
Halter O 75/150:35 | REHAU Bracket O 75/150, for double connection | REHAU_RAUTITAN_Bracket O 75 150:REHAU_RAUTITAN_Bracket O 75 150
Halter O 75/150:36 | REHAU Bracket O 75/150, for double connection | REHAU_RAUTITAN_Bracket O 75 150:REHAU_RAUTITAN_Bracket O 75 150
Halter O 75/150:37 | REHAU Bracket O 75/150, for double connection | REHAU_RAUTITAN_Bracket O 75 150:REHAU_RAUTITAN_Bracket O 75 150
Halter O 75/150:38 | REHAU Bracket O 75/150, for double connection | REHAU_RAUTITAN_Bracket O 75 150:REHAU_RAUTITAN_Bracket O 75 150
Halter O 75/150:39 | REHAU Bracket O 75/150, for double connection | REHAU_RAUTITAN_Bracket O 75 150:REHAU_RAUTITAN_Bracket O 75 150
Halter O 75/150:40 | REHAU Bracket O 75/150, for double connection | REHAU_RAUTITAN_Bracket O 75 150:REHAU_RAUTITAN_Bracket O 75 150
Halter O 75/150:41 | REHAU Bracket O 75/150, for double connection | REHAU_RAUTITAN_Bracket O 75 150:REHAU_RAUTITAN_Bracket O 75 150
Halter O 75/150:42 | REHAU Bracket O 75/150, for double connection | REHAU_RAUTITAN_Bracket O 75 150:REHAU_RAUTITAN_Bracket O 75 150
Halter O 75/150:43 | REHAU Bracket O 75/150, for double connection | REHAU_RAUTITAN_Bracket O 75 150:REHAU_RAUTITAN_Bracket O 75 150
Halter O 75/150:44 | REHAU Bracket O 75/150, for double connection | REHAU_RAUTITAN_Bracket O 75 150:REHAU_RAUTITAN_Bracket O 75 150
Halter O 75/150:45 | REHAU Bracket O 75/150, for double connection | REHAU_RAUTITAN_Bracket O 75 150:REHAU_RAUTITAN_Bracket O 75 150
