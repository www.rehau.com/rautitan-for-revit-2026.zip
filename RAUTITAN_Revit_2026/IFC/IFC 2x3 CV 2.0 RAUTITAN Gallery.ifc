Properties of the parts of a building model (IFC2X3), part 7 of 9

# IfcFlowFitting: Sleeve:LX 7,4 (197)
Name (Sleeve:LX 7,4:...) | DN1 (mm) | L1 (mm) | Volume (m3) | Description long | GTIN | PID | Product Group | Product URL | Weight
1067905 | 25 | 34 | 0.0000131097 | REHAU Compression sleeve RAUT. MX/LX 32 | 4007360168698 | 11371661001 | 1961 | https://oxomi.com/p/3000126/datasheet/-/11371661001 | 0.096
1067907 | 20 | 29 | 0.0000058041 | REHAU Compression sleeve RAUT. MX/LX +G 25 | 4007360377519 | 12596251402 | 1960 | https://oxomi.com/p/3000126/datasheet/-/12596251402 | 0.046
1067912 | 20 | 29 | 0.0000058041 | REHAU Compression sleeve RAUT. MX/LX +G 25 | 4007360377519 | 12596251402 | 1960 | https://oxomi.com/p/3000126/datasheet/-/12596251402 | 0.046
1067914 | 15 | 25 | 0.00000393937 | REHAU Compression sleeve RAUT. MX/LX 20 | 4007360031060 | 12596151002 | 1959 | https://oxomi.com/p/3000126/datasheet/-/12596151002 | 0.028
1067919 | 15 | 25 | 0.00000393937 | REHAU Compression sleeve RAUT. MX/LX 20 | 4007360031060 | 12596151002 | 1959 | https://oxomi.com/p/3000126/datasheet/-/12596151002 | 0.028
1077995 | 15 | 25 | 0.00000393937 | REHAU Compression sleeve RAUT. MX/LX 20 | 4007360031060 | 12596151002 | 1959 | https://oxomi.com/p/3000126/datasheet/-/12596151002 | 0.028
1077997 | 15 | 25 | 0.00000393937 | REHAU Compression sleeve RAUT. MX/LX 20 | 4007360031060 | 12596151002 | 1959 | https://oxomi.com/p/3000126/datasheet/-/12596151002 | 0.028
1078001 | 20 | 29 | 0.0000058041 | REHAU Compression sleeve RAUT. MX/LX +G 25 | 4007360377519 | 12596251402 | 1960 | https://oxomi.com/p/3000126/datasheet/-/12596251402 | 0.046
1078003 | 20 | 29 | 0.0000058041 | REHAU Compression sleeve RAUT. MX/LX +G 25 | 4007360377519 | 12596251402 | 1960 | https://oxomi.com/p/3000126/datasheet/-/12596251402 | 0.046
1078005 | 25 | 34 | 0.0000131097 | REHAU Compression sleeve RAUT. MX/LX 32 | 4007360168698 | 11371661001 | 1961 | https://oxomi.com/p/3000126/datasheet/-/11371661001 | 0.096
1078007 | 25 | 34 | 0.0000131097 | REHAU Compression sleeve RAUT. MX/LX 32 | 4007360168698 | 11371661001 | 1961 | https://oxomi.com/p/3000126/datasheet/-/11371661001 | 0.096
1078011 | 32 | 37 | 0.0000199643 | REHAU Compression sleeve RAUT. MX/LX 40 | 4007360186487 | 11372961001 | 1962 | https://oxomi.com/p/3000126/datasheet/-/11372961001 | 0.162
1078013 | 32 | 37 | 0.0000199643 | REHAU Compression sleeve RAUT. MX/LX 40 | 4007360186487 | 11372961001 | 1962 | https://oxomi.com/p/3000126/datasheet/-/11372961001 | 0.162
1078017 | 40 | 44 | 0.0000372872 | REHAU Compression sleeve RAUTITAN MX/LX 50 | 4007360031817 | 11397711002 | 1963 | https://oxomi.com/p/3000126/datasheet/-/11397711002 | 0.293
1078019 | 40 | 44 | 0.0000372872 | REHAU Compression sleeve RAUTITAN MX/LX 50 | 4007360031817 | 11397711002 | 1963 | https://oxomi.com/p/3000126/datasheet/-/11397711002 | 0.293
1078023 | 50 | 53 | 0.0000553035 | REHAU Compression sleeve RAUTITAN MX/LX 63 | 4007360031824 | 11397811002 | 1964 | https://oxomi.com/p/3000126/datasheet/-/11397811002 | 0.439
1078025 | 50 | 53 | 0.0000553035 | REHAU Compression sleeve RAUTITAN MX/LX 63 | 4007360031824 | 11397811002 | 1964 | https://oxomi.com/p/3000126/datasheet/-/11397811002 | 0.439
1078544 | 40 | 44 | 0.0000372872 | REHAU Compression sleeve RAUTITAN MX/LX 50 | 4007360031817 | 11397711002 | 1963 | https://oxomi.com/p/3000126/datasheet/-/11397711002 | 0.293
1078546 | 40 | 44 | 0.0000372872 | REHAU Compression sleeve RAUTITAN MX/LX 50 | 4007360031817 | 11397711002 | 1963 | https://oxomi.com/p/3000126/datasheet/-/11397711002 | 0.293
1078548 | 50 | 53 | 0.0000553035 | REHAU Compression sleeve RAUTITAN MX/LX 63 | 4007360031824 | 11397811002 | 1964 | https://oxomi.com/p/3000126/datasheet/-/11397811002 | 0.439
1078550 | 50 | 53 | 0.0000553035 | REHAU Compression sleeve RAUTITAN MX/LX 63 | 4007360031824 | 11397811002 | 1964 | https://oxomi.com/p/3000126/datasheet/-/11397811002 | 0.439
1078552 | 50 | 53 | 0.0000553035 | REHAU Compression sleeve RAUTITAN MX/LX 63 | 4007360031824 | 11397811002 | 1964 | https://oxomi.com/p/3000126/datasheet/-/11397811002 | 0.439
1078554 | 50 | 53 | 0.0000553035 | REHAU Compression sleeve RAUTITAN MX/LX 63 | 4007360031824 | 11397811002 | 1964 | https://oxomi.com/p/3000126/datasheet/-/11397811002 | 0.439
1078556 | 40 | 44 | 0.0000372872 | REHAU Compression sleeve RAUTITAN MX/LX 50 | 4007360031817 | 11397711002 | 1963 | https://oxomi.com/p/3000126/datasheet/-/11397711002 | 0.293
1078558 | 40 | 44 | 0.0000372872 | REHAU Compression sleeve RAUTITAN MX/LX 50 | 4007360031817 | 11397711002 | 1963 | https://oxomi.com/p/3000126/datasheet/-/11397711002 | 0.293
1078839 | 40 | 44 | 0.0000372872 | REHAU Compression sleeve RAUTITAN MX/LX 50 | 4007360031817 | 11397711002 | 1963 | https://oxomi.com/p/3000126/datasheet/-/11397711002 | 0.293
1078841 | 50 | 53 | 0.0000553035 | REHAU Compression sleeve RAUTITAN MX/LX 63 | 4007360031824 | 11397811002 | 1964 | https://oxomi.com/p/3000126/datasheet/-/11397811002 | 0.439
1078847 | 40 | 44 | 0.0000372872 | REHAU Compression sleeve RAUTITAN MX/LX 50 | 4007360031817 | 11397711002 | 1963 | https://oxomi.com/p/3000126/datasheet/-/11397711002 | 0.293
1078849 | 50 | 53 | 0.0000553035 | REHAU Compression sleeve RAUTITAN MX/LX 63 | 4007360031824 | 11397811002 | 1964 | https://oxomi.com/p/3000126/datasheet/-/11397811002 | 0.439
1078853 | 40 | 44 | 0.0000372872 | REHAU Compression sleeve RAUTITAN MX/LX 50 | 4007360031817 | 11397711002 | 1963 | https://oxomi.com/p/3000126/datasheet/-/11397711002 | 0.293
1078855 | 50 | 53 | 0.0000553035 | REHAU Compression sleeve RAUTITAN MX/LX 63 | 4007360031824 | 11397811002 | 1964 | https://oxomi.com/p/3000126/datasheet/-/11397811002 | 0.439
1078857 | 40 | 44 | 0.0000372872 | REHAU Compression sleeve RAUTITAN MX/LX 50 | 4007360031817 | 11397711002 | 1963 | https://oxomi.com/p/3000126/datasheet/-/11397711002 | 0.293
1078859 | 50 | 53 | 0.0000553035 | REHAU Compression sleeve RAUTITAN MX/LX 63 | 4007360031824 | 11397811002 | 1964 | https://oxomi.com/p/3000126/datasheet/-/11397811002 | 0.439
1078861 | 40 | 44 | 0.0000372872 | REHAU Compression sleeve RAUTITAN MX/LX 50 | 4007360031817 | 11397711002 | 1963 | https://oxomi.com/p/3000126/datasheet/-/11397711002 | 0.293
1078863 | 50 | 53 | 0.0000553035 | REHAU Compression sleeve RAUTITAN MX/LX 63 | 4007360031824 | 11397811002 | 1964 | https://oxomi.com/p/3000126/datasheet/-/11397811002 | 0.439
1078865 | 40 | 44 | 0.0000372872 | REHAU Compression sleeve RAUTITAN MX/LX 50 | 4007360031817 | 11397711002 | 1963 | https://oxomi.com/p/3000126/datasheet/-/11397711002 | 0.293
1078877 | 40 | 44 | 0.0000372872 | REHAU Compression sleeve RAUTITAN MX/LX 50 | 4007360031817 | 11397711002 | 1963 | https://oxomi.com/p/3000126/datasheet/-/11397711002 | 0.293
1078879 | 50 | 53 | 0.0000553035 | REHAU Compression sleeve RAUTITAN MX/LX 63 | 4007360031824 | 11397811002 | 1964 | https://oxomi.com/p/3000126/datasheet/-/11397811002 | 0.439
1078885 | 40 | 44 | 0.0000372872 | REHAU Compression sleeve RAUTITAN MX/LX 50 | 4007360031817 | 11397711002 | 1963 | https://oxomi.com/p/3000126/datasheet/-/11397711002 | 0.293
1078887 | 50 | 53 | 0.0000553035 | REHAU Compression sleeve RAUTITAN MX/LX 63 | 4007360031824 | 11397811002 | 1964 | https://oxomi.com/p/3000126/datasheet/-/11397811002 | 0.439
1078891 | 40 | 44 | 0.0000372872 | REHAU Compression sleeve RAUTITAN MX/LX 50 | 4007360031817 | 11397711002 | 1963 | https://oxomi.com/p/3000126/datasheet/-/11397711002 | 0.293
1078893 | 50 | 53 | 0.0000553035 | REHAU Compression sleeve RAUTITAN MX/LX 63 | 4007360031824 | 11397811002 | 1964 | https://oxomi.com/p/3000126/datasheet/-/11397811002 | 0.439
1078895 | 40 | 44 | 0.0000372872 | REHAU Compression sleeve RAUTITAN MX/LX 50 | 4007360031817 | 11397711002 | 1963 | https://oxomi.com/p/3000126/datasheet/-/11397711002 | 0.293
1078897 | 50 | 53 | 0.0000553035 | REHAU Compression sleeve RAUTITAN MX/LX 63 | 4007360031824 | 11397811002 | 1964 | https://oxomi.com/p/3000126/datasheet/-/11397811002 | 0.439
1078899 | 40 | 44 | 0.0000372872 | REHAU Compression sleeve RAUTITAN MX/LX 50 | 4007360031817 | 11397711002 | 1963 | https://oxomi.com/p/3000126/datasheet/-/11397711002 | 0.293
1078901 | 50 | 53 | 0.0000553035 | REHAU Compression sleeve RAUTITAN MX/LX 63 | 4007360031824 | 11397811002 | 1964 | https://oxomi.com/p/3000126/datasheet/-/11397811002 | 0.439
1078903 | 40 | 44 | 0.0000372872 | REHAU Compression sleeve RAUTITAN MX/LX 50 | 4007360031817 | 11397711002 | 1963 | https://oxomi.com/p/3000126/datasheet/-/11397711002 | 0.293
1078915 | 40 | 44 | 0.0000372872 | REHAU Compression sleeve RAUTITAN MX/LX 50 | 4007360031817 | 11397711002 | 1963 | https://oxomi.com/p/3000126/datasheet/-/11397711002 | 0.293
1078917 | 50 | 53 | 0.0000553035 | REHAU Compression sleeve RAUTITAN MX/LX 63 | 4007360031824 | 11397811002 | 1964 | https://oxomi.com/p/3000126/datasheet/-/11397811002 | 0.439
1078925 | 40 | 44 | 0.0000372872 | REHAU Compression sleeve RAUTITAN MX/LX 50 | 4007360031817 | 11397711002 | 1963 | https://oxomi.com/p/3000126/datasheet/-/11397711002 | 0.293
1078967 | 40 | 44 | 0.0000372872 | REHAU Compression sleeve RAUTITAN MX/LX 50 | 4007360031817 | 11397711002 | 1963 | https://oxomi.com/p/3000126/datasheet/-/11397711002 | 0.293
1078971 | 50 | 53 | 0.0000553035 | REHAU Compression sleeve RAUTITAN MX/LX 63 | 4007360031824 | 11397811002 | 1964 | https://oxomi.com/p/3000126/datasheet/-/11397811002 | 0.439
1078973 | 40 | 44 | 0.0000372872 | REHAU Compression sleeve RAUTITAN MX/LX 50 | 4007360031817 | 11397711002 | 1963 | https://oxomi.com/p/3000126/datasheet/-/11397711002 | 0.293
1079011 | 40 | 44 | 0.0000372872 | REHAU Compression sleeve RAUTITAN MX/LX 50 | 4007360031817 | 11397711002 | 1963 | https://oxomi.com/p/3000126/datasheet/-/11397711002 | 0.293
1079015 | 50 | 53 | 0.0000553035 | REHAU Compression sleeve RAUTITAN MX/LX 63 | 4007360031824 | 11397811002 | 1964 | https://oxomi.com/p/3000126/datasheet/-/11397811002 | 0.439
1079017 | 40 | 44 | 0.0000372872 | REHAU Compression sleeve RAUTITAN MX/LX 50 | 4007360031817 | 11397711002 | 1963 | https://oxomi.com/p/3000126/datasheet/-/11397711002 | 0.293
1079027 | 40 | 44 | 0.0000372872 | REHAU Compression sleeve RAUTITAN MX/LX 50 | 4007360031817 | 11397711002 | 1963 | https://oxomi.com/p/3000126/datasheet/-/11397711002 | 0.293
1079113 | 40 | 44 | 0.0000372872 | REHAU Compression sleeve RAUTITAN MX/LX 50 | 4007360031817 | 11397711002 | 1963 | https://oxomi.com/p/3000126/datasheet/-/11397711002 | 0.293
1079115 | 40 | 44 | 0.0000372872 | REHAU Compression sleeve RAUTITAN MX/LX 50 | 4007360031817 | 11397711002 | 1963 | https://oxomi.com/p/3000126/datasheet/-/11397711002 | 0.293
1079126 | 50 | 53 | 0.0000553035 | REHAU Compression sleeve RAUTITAN MX/LX 63 | 4007360031824 | 11397811002 | 1964 | https://oxomi.com/p/3000126/datasheet/-/11397811002 | 0.439
1079128 | 50 | 53 | 0.0000553035 | REHAU Compression sleeve RAUTITAN MX/LX 63 | 4007360031824 | 11397811002 | 1964 | https://oxomi.com/p/3000126/datasheet/-/11397811002 | 0.439
1086535 | 40 | 44 | 0.0000372872 | REHAU Compression sleeve RAUTITAN MX/LX 50 | 4007360031817 | 11397711002 | 1963 | https://oxomi.com/p/3000126/datasheet/-/11397711002 | 0.293
1086537 | 40 | 44 | 0.0000372872 | REHAU Compression sleeve RAUTITAN MX/LX 50 | 4007360031817 | 11397711002 | 1963 | https://oxomi.com/p/3000126/datasheet/-/11397711002 | 0.293
1086541 | 50 | 53 | 0.0000553035 | REHAU Compression sleeve RAUTITAN MX/LX 63 | 4007360031824 | 11397811002 | 1964 | https://oxomi.com/p/3000126/datasheet/-/11397811002 | 0.439
1086543 | 50 | 53 | 0.0000553035 | REHAU Compression sleeve RAUTITAN MX/LX 63 | 4007360031824 | 11397811002 | 1964 | https://oxomi.com/p/3000126/datasheet/-/11397811002 | 0.439

# IfcFlowFitting: Sleeve:LX 7,4 (48)
In: REHAU Starting view
Type - Material: Br, <Unnamed>
Type - Other - Category: Pipe Fittings; Family Name: Sleeve
Type - Constraints - Default Elevation: 0 mm
Type - Identity Data - Cost: 0; Description: LX 7,4; Manufacturer: REHAU; Model: LX 7,4; REHAU Info: 14.02.2024-420668-420668; Type Name: LX 7,4
Type - Materials and Finishes - Mat. Sleeve: Br
Type - Pset_ManufacturerTypeInformation - Manufacturer: REHAU
Pset_DistributionFlowElementCommon - Reference: Sleeve:LX 7,4; sets with these values: 2
Other - IsCustom: yes; Family: Sleeve; Family and Type: Sleeve: LX 7,4; T1: Sleeve DN; Type: LX 7,4; Type Id: 986514
Constraints - Elevation from Level: 0 mm; Level: REHAU Starting view; Moves With Nearby Elements: no
Data - PID Check: 0 mm; Language: Description en; Language Tender Text: Tender Text en; Region Check: Check DE; Region PID: PID DE; Region URL: Product URL DE
Dimensions - Area: 0.00262625 m2; Volume: 0.0000142985 m3
Identity Data - Sorting: 0; ETIM Class: EC011668; ETIM Group: EG015540; ETIM Name: Accessories/spare parts for fittings; PID: -; Tender text: -
Phasing - Phase Created: New Construction
Insulation - Insulation Thickness: 0 mm
Name (Sleeve:LX 7,4:...) | DN1 (mm) | L1 (mm) | Description long | GTIN | Product Group | Product URL | Weight
986597 | 10 | 15 | REHAU compression sleeve SDR 11/7,4 LX 12 x 1,1 / 12 x 1,7 / 12 x 2,0 | 4007360057114 | 1957 | https://oxomi.com/p/3000126/datasheet/-/11386131001 | 0.01
986599 | 10 | 15 | REHAU compression sleeve SDR 11/7,4 LX 12 x 1,1 / 12 x 1,7 / 12 x 2,0 | 4007360057114 | 1957 | https://oxomi.com/p/3000126/datasheet/-/11386131001 | 0.01
1005928 | 10 | 15 | REHAU compression sleeve SDR 11/7,4 LX 12 x 1,1 / 12 x 1,7 / 12 x 2,0 | 4007360057114 | 1957 | https://oxomi.com/p/3000126/datasheet/-/11386131001 | 0.01
1005930 | 10 | 15 | REHAU compression sleeve SDR 11/7,4 LX 12 x 1,1 / 12 x 1,7 / 12 x 2,0 | 4007360057114 | 1957 | https://oxomi.com/p/3000126/datasheet/-/11386131001 | 0.01
1005932 | 10 | 15 | REHAU compression sleeve SDR 11/7,4 LX 12 x 1,1 / 12 x 1,7 / 12 x 2,0 | 4007360057114 | 1957 | https://oxomi.com/p/3000126/datasheet/-/11386131001 | 0.01
1005936 | 12 | 24 | REHAU Compression sleeve RAUT. MX/LX 16 | 4007360031053 | 1958 | https://oxomi.com/p/3000126/datasheet/-/12596051002 | 0.025
1005938 | 12 | 24 | REHAU Compression sleeve RAUT. MX/LX 16 | 4007360031053 | 1958 | https://oxomi.com/p/3000126/datasheet/-/12596051002 | 0.025
1005940 | 12 | 24 | REHAU Compression sleeve RAUT. MX/LX 16 | 4007360031053 | 1958 | https://oxomi.com/p/3000126/datasheet/-/12596051002 | 0.025
1005991 | 12 | 24 | REHAU Compression sleeve RAUT. MX/LX 16 | 4007360031053 | 1958 | https://oxomi.com/p/3000126/datasheet/-/12596051002 | 0.025
1005993 | 10 | 15 | REHAU compression sleeve SDR 11/7,4 LX 12 x 1,1 / 12 x 1,7 / 12 x 2,0 | 4007360057114 | 1957 | https://oxomi.com/p/3000126/datasheet/-/11386131001 | 0.01
1005995 | 12 | 24 | REHAU Compression sleeve RAUT. MX/LX 16 | 4007360031053 | 1958 | https://oxomi.com/p/3000126/datasheet/-/12596051002 | 0.025
1006043 | 12 | 24 | REHAU Compression sleeve RAUT. MX/LX 16 | 4007360031053 | 1958 | https://oxomi.com/p/3000126/datasheet/-/12596051002 | 0.025
1006052 | 12 | 24 | REHAU Compression sleeve RAUT. MX/LX 16 | 4007360031053 | 1958 | https://oxomi.com/p/3000126/datasheet/-/12596051002 | 0.025
1006093 | 10 | 15 | REHAU compression sleeve SDR 11/7,4 LX 12 x 1,1 / 12 x 1,7 / 12 x 2,0 | 4007360057114 | 1957 | https://oxomi.com/p/3000126/datasheet/-/11386131001 | 0.01
1006109 | 12 | 24 | REHAU Compression sleeve RAUT. MX/LX 16 | 4007360031053 | 1958 | https://oxomi.com/p/3000126/datasheet/-/12596051002 | 0.025
1006113 | 12 | 24 | REHAU Compression sleeve RAUT. MX/LX 16 | 4007360031053 | 1958 | https://oxomi.com/p/3000126/datasheet/-/12596051002 | 0.025
1006127 | 12 | 24 | REHAU Compression sleeve RAUT. MX/LX 16 | 4007360031053 | 1958 | https://oxomi.com/p/3000126/datasheet/-/12596051002 | 0.025
1006129 | 10 | 15 | REHAU compression sleeve SDR 11/7,4 LX 12 x 1,1 / 12 x 1,7 / 12 x 2,0 | 4007360057114 | 1957 | https://oxomi.com/p/3000126/datasheet/-/11386131001 | 0.01
1006131 | 10 | 15 | REHAU compression sleeve SDR 11/7,4 LX 12 x 1,1 / 12 x 1,7 / 12 x 2,0 | 4007360057114 | 1957 | https://oxomi.com/p/3000126/datasheet/-/11386131001 | 0.01
1006161 | 12 | 24 | REHAU Compression sleeve RAUT. MX/LX 16 | 4007360031053 | 1958 | https://oxomi.com/p/3000126/datasheet/-/12596051002 | 0.025
1006163 | 12 | 24 | REHAU Compression sleeve RAUT. MX/LX 16 | 4007360031053 | 1958 | https://oxomi.com/p/3000126/datasheet/-/12596051002 | 0.025
1006168 | 12 | 24 | REHAU Compression sleeve RAUT. MX/LX 16 | 4007360031053 | 1958 | https://oxomi.com/p/3000126/datasheet/-/12596051002 | 0.025
1006170 | 12 | 24 | REHAU Compression sleeve RAUT. MX/LX 16 | 4007360031053 | 1958 | https://oxomi.com/p/3000126/datasheet/-/12596051002 | 0.025
1006172 | 10 | 15 | REHAU compression sleeve SDR 11/7,4 LX 12 x 1,1 / 12 x 1,7 / 12 x 2,0 | 4007360057114 | 1957 | https://oxomi.com/p/3000126/datasheet/-/11386131001 | 0.01
1006198 | 12 | 24 | REHAU Compression sleeve RAUT. MX/LX 16 | 4007360031053 | 1958 | https://oxomi.com/p/3000126/datasheet/-/12596051002 | 0.025
1006215 | 12 | 24 | REHAU Compression sleeve RAUT. MX/LX 16 | 4007360031053 | 1958 | https://oxomi.com/p/3000126/datasheet/-/12596051002 | 0.025
1007418 | 10 | 15 | REHAU compression sleeve SDR 11/7,4 LX 12 x 1,1 / 12 x 1,7 / 12 x 2,0 | 4007360057114 | 1957 | https://oxomi.com/p/3000126/datasheet/-/11386131001 | 0.01
1007420 | 10 | 15 | REHAU compression sleeve SDR 11/7,4 LX 12 x 1,1 / 12 x 1,7 / 12 x 2,0 | 4007360057114 | 1957 | https://oxomi.com/p/3000126/datasheet/-/11386131001 | 0.01
1007422 | 10 | 15 | REHAU compression sleeve SDR 11/7,4 LX 12 x 1,1 / 12 x 1,7 / 12 x 2,0 | 4007360057114 | 1957 | https://oxomi.com/p/3000126/datasheet/-/11386131001 | 0.01
1007468 | 10 | 15 | REHAU compression sleeve SDR 11/7,4 LX 12 x 1,1 / 12 x 1,7 / 12 x 2,0 | 4007360057114 | 1957 | https://oxomi.com/p/3000126/datasheet/-/11386131001 | 0.01
1007540 | 10 | 15 | REHAU compression sleeve SDR 11/7,4 LX 12 x 1,1 / 12 x 1,7 / 12 x 2,0 | 4007360057114 | 1957 | https://oxomi.com/p/3000126/datasheet/-/11386131001 | 0.01
1007564 | 10 | 15 | REHAU compression sleeve SDR 11/7,4 LX 12 x 1,1 / 12 x 1,7 / 12 x 2,0 | 4007360057114 | 1957 | https://oxomi.com/p/3000126/datasheet/-/11386131001 | 0.01
1007566 | 10 | 15 | REHAU compression sleeve SDR 11/7,4 LX 12 x 1,1 / 12 x 1,7 / 12 x 2,0 | 4007360057114 | 1957 | https://oxomi.com/p/3000126/datasheet/-/11386131001 | 0.01
1007596 | 10 | 15 | REHAU compression sleeve SDR 11/7,4 LX 12 x 1,1 / 12 x 1,7 / 12 x 2,0 | 4007360057114 | 1957 | https://oxomi.com/p/3000126/datasheet/-/11386131001 | 0.01
1067921 | 12 | 24 | REHAU Compression sleeve RAUT. MX/LX 16 | 4007360031053 | 1958 | https://oxomi.com/p/3000126/datasheet/-/12596051002 | 0.025
1077983 | 10 | 15 | REHAU compression sleeve SDR 11/7,4 LX 12 x 1,1 / 12 x 1,7 / 12 x 2,0 | 4007360057114 | 1957 | https://oxomi.com/p/3000126/datasheet/-/11386131001 | 0.01
1077985 | 10 | 15 | REHAU compression sleeve SDR 11/7,4 LX 12 x 1,1 / 12 x 1,7 / 12 x 2,0 | 4007360057114 | 1957 | https://oxomi.com/p/3000126/datasheet/-/11386131001 | 0.01
1077989 | 12 | 24 | REHAU Compression sleeve RAUT. MX/LX 16 | 4007360031053 | 1958 | https://oxomi.com/p/3000126/datasheet/-/12596051002 | 0.025
1077991 | 12 | 24 | REHAU Compression sleeve RAUT. MX/LX 16 | 4007360031053 | 1958 | https://oxomi.com/p/3000126/datasheet/-/12596051002 | 0.025
1440896 | 12 | 24 | REHAU Compression sleeve RAUT. MX/LX 16 | 4007360031053 | 1958 | https://oxomi.com/p/3000126/datasheet/-/12596051002 | 0.025
1440898 | 12 | 24 | REHAU Compression sleeve RAUT. MX/LX 16 | 4007360031053 | 1958 | https://oxomi.com/p/3000126/datasheet/-/12596051002 | 0.025
1440942 | 10 | 15 | REHAU compression sleeve SDR 11/7,4 LX 12 x 1,1 / 12 x 1,7 / 12 x 2,0 | 4007360057114 | 1957 | https://oxomi.com/p/3000126/datasheet/-/11386131001 | 0.01
1440944 | 10 | 15 | REHAU compression sleeve SDR 11/7,4 LX 12 x 1,1 / 12 x 1,7 / 12 x 2,0 | 4007360057114 | 1957 | https://oxomi.com/p/3000126/datasheet/-/11386131001 | 0.01
1441232 | 10 | 15 | REHAU compression sleeve SDR 11/7,4 LX 12 x 1,1 / 12 x 1,7 / 12 x 2,0 | 4007360057114 | 1957 | https://oxomi.com/p/3000126/datasheet/-/11386131001 | 0.01
1441234 | 10 | 15 | REHAU compression sleeve SDR 11/7,4 LX 12 x 1,1 / 12 x 1,7 / 12 x 2,0 | 4007360057114 | 1957 | https://oxomi.com/p/3000126/datasheet/-/11386131001 | 0.01
1451460 | 10 | 15 | REHAU compression sleeve SDR 11/7,4 LX 12 x 1,1 / 12 x 1,7 / 12 x 2,0 | 4007360057114 | 1957 | https://oxomi.com/p/3000126/datasheet/-/11386131001 | 0.01
1454193 | 12 | 24 | REHAU Compression sleeve RAUT. MX/LX 16 | 4007360031053 | 1958 | https://oxomi.com/p/3000126/datasheet/-/12596051002 | 0.025
1454195 | 10 | 15 | REHAU compression sleeve SDR 11/7,4 LX 12 x 1,1 / 12 x 1,7 / 12 x 2,0 | 4007360057114 | 1957 | https://oxomi.com/p/3000126/datasheet/-/11386131001 | 0.01

# IfcFlowFitting: Sleeve:PX 7,4 (450)
In: REHAU Starting view
Type - Material: PX
Type - Other - Category: Pipe Fittings; Family Name: Sleeve
Type - Constraints - Default Elevation: 0 mm
Type - Identity Data - Cost: 0; Description: PX 7,4; Manufacturer: REHAU; Model: PX 7,4; REHAU Info: 14.02.2024-420668-420668; Type Name: PX 7,4
Type - Materials and Finishes - Mat. Sleeve: PX
Type - Pset_ManufacturerTypeInformation - Manufacturer: REHAU
Pset_DistributionFlowElementCommon - Reference: Sleeve:PX 7,4; sets with these values: 2
Other - IsCustom: no; Family: Sleeve; Family and Type: Sleeve: PX 7,4; T1: Sleeve DN; Type: PX 7,4; Type Id: 986515
Constraints - Elevation from Level: 0 mm; Level: REHAU Starting view; Moves With Nearby Elements: no
Data - Language: Description en; PID Check: 1 mm; Region Check: Check DE; Region PID: PID DE
Dimensions - Area: 0.00262625 m2
Identity Data - Sorting: 0; ETIM Class: EC011668; ETIM Group: EG015540; ETIM Name: Accessories/spare parts for fittings; Tender text: -
Phasing - Phase Created: New Construction
Insulation - Insulation Thickness: 0 mm
Name (Sleeve:PX 7,4:...) | Language Tender Text | Region URL | DN1 (mm) | L1 (mm) | Volume (m3) | Description long | GTIN | PID | Product Group | Product URL | Weight
986656 | Tender Text en | Product URL DE | 12 | 23.7 | 0.00000312848 | REHAU Compression sleeve RAUTITAN PX 16 | 4007360361204 | 11600011001 | 1947 | https://oxomi.com/p/3000126/datasheet/-/11600011001 | 0.0076
986658 | Tender Text en | Product URL DE | 12 | 23.7 | 0.00000312848 | REHAU Compression sleeve RAUTITAN PX 16 | 4007360361204 | 11600011001 | 1947 | https://oxomi.com/p/3000126/datasheet/-/11600011001 | 0.0076
986662 | Tender Text en | Product URL DE | 15 | 25 | 0.00000516767 | REHAU Compression sleeve RAUTITAN PX 20 | 4007360361211 | 11600021001 | 1949 | https://oxomi.com/p/3000126/datasheet/-/11600021001 | 0.011
986664 | Tender Text en | Product URL DE | 15 | 25 | 0.00000516767 | REHAU Compression sleeve RAUTITAN PX 20 | 4007360361211 | 11600021001 | 1949 | https://oxomi.com/p/3000126/datasheet/-/11600021001 | 0.011
986669 | Tender Text en | Product URL DE | 20 | 27.2 | 0.0000087028 | REHAU Compression sleeve RAUTITAN PX 25 | 4007360361228 | 11600031001 | 1950 | https://oxomi.com/p/3000126/datasheet/-/11600031001 | 0.015828
986671 | Tender Text en | Product URL DE | 20 | 27.2 | 0.0000087028 | REHAU Compression sleeve RAUTITAN PX 25 | 4007360361228 | 11600031001 | 1950 | https://oxomi.com/p/3000126/datasheet/-/11600031001 | 0.015828
986676 | Tender Text en | Product URL DE | 25 | 34 | 0.0000174355 | REHAU Compression sleeve RAUTITAN PX 32 | 4007360361235 | 11600041001 | 1951 | https://oxomi.com/p/3000126/datasheet/-/11600041001 | 0.027828
986678 | Tender Text en | Product URL DE | 25 | 34 | 0.0000174355 | REHAU Compression sleeve RAUTITAN PX 32 | 4007360361235 | 11600041001 | 1951 | https://oxomi.com/p/3000126/datasheet/-/11600041001 | 0.027828
986682 | Tender Text en | Product URL DE | 32 | 37.8 | 0.0000303041 | REHAU Compression sleeve RAUTITAN PX 40 | 4007360361242 | 11600051001 | 1952 | https://oxomi.com/p/3000126/datasheet/-/11600051001 | 0.03861
986684 | Tender Text en | Product URL DE | 32 | 37.8 | 0.0000303041 | REHAU Compression sleeve RAUTITAN PX 40 | 4007360361242 | 11600051001 | 1952 | https://oxomi.com/p/3000126/datasheet/-/11600051001 | 0.03861
1007424 | Tender Text en | Product URL DE | 12 | 23.7 | 0.00000312848 | REHAU Compression sleeve RAUTITAN PX 16 | 4007360361204 | 11600011001 | 1947 | https://oxomi.com/p/3000126/datasheet/-/11600011001 | 0.0076
1007426 | Tender Text en | Product URL DE | 12 | 23.7 | 0.00000312848 | REHAU Compression sleeve RAUTITAN PX 16 | 4007360361204 | 11600011001 | 1947 | https://oxomi.com/p/3000126/datasheet/-/11600011001 | 0.0076
1007428 | Tender Text en | Product URL DE | 12 | 23.7 | 0.00000312848 | REHAU Compression sleeve RAUTITAN PX 16 | 4007360361204 | 11600011001 | 1947 | https://oxomi.com/p/3000126/datasheet/-/11600011001 | 0.0076
1007430 | Tender Text en | Product URL DE | 20 | 27.2 | 0.0000087028 | REHAU Compression sleeve RAUTITAN PX 25 | 4007360361228 | 11600031001 | 1950 | https://oxomi.com/p/3000126/datasheet/-/11600031001 | 0.015828
1007432 | Tender Text en | Product URL DE | 20 | 27.2 | 0.0000087028 | REHAU Compression sleeve RAUTITAN PX 25 | 4007360361228 | 11600031001 | 1950 | https://oxomi.com/p/3000126/datasheet/-/11600031001 | 0.015828
1007434 | Tender Text en | Product URL DE | 20 | 27.2 | 0.0000087028 | REHAU Compression sleeve RAUTITAN PX 25 | 4007360361228 | 11600031001 | 1950 | https://oxomi.com/p/3000126/datasheet/-/11600031001 | 0.015828
1007436 | Tender Text en | Product URL DE | 25 | 34 | 0.0000174355 | REHAU Compression sleeve RAUTITAN PX 32 | 4007360361235 | 11600041001 | 1951 | https://oxomi.com/p/3000126/datasheet/-/11600041001 | 0.027828
1007438 | Tender Text en | Product URL DE | 25 | 34 | 0.0000174355 | REHAU Compression sleeve RAUTITAN PX 32 | 4007360361235 | 11600041001 | 1951 | https://oxomi.com/p/3000126/datasheet/-/11600041001 | 0.027828
1007440 | Tender Text en | Product URL DE | 25 | 34 | 0.0000174355 | REHAU Compression sleeve RAUTITAN PX 32 | 4007360361235 | 11600041001 | 1951 | https://oxomi.com/p/3000126/datasheet/-/11600041001 | 0.027828
1007442 | Tender Text en | Product URL DE | 32 | 37.8 | 0.0000303041 | REHAU Compression sleeve RAUTITAN PX 40 | 4007360361242 | 11600051001 | 1952 | https://oxomi.com/p/3000126/datasheet/-/11600051001 | 0.03861
1007444 | Tender Text en | Product URL DE | 32 | 37.8 | 0.0000303041 | REHAU Compression sleeve RAUTITAN PX 40 | 4007360361242 | 11600051001 | 1952 | https://oxomi.com/p/3000126/datasheet/-/11600051001 | 0.03861
1007446 | Tender Text en | Product URL DE | 32 | 37.8 | 0.0000303041 | REHAU Compression sleeve RAUTITAN PX 40 | 4007360361242 | 11600051001 | 1952 | https://oxomi.com/p/3000126/datasheet/-/11600051001 | 0.03861
1007460 | Tender Text en | Product URL DE | 15 | 25 | 0.00000516767 | REHAU Compression sleeve RAUTITAN PX 20 | 4007360361211 | 11600021001 | 1949 | https://oxomi.com/p/3000126/datasheet/-/11600021001 | 0.011
1007462 | Tender Text en | Product URL DE | 15 | 25 | 0.00000516767 | REHAU Compression sleeve RAUTITAN PX 20 | 4007360361211 | 11600021001 | 1949 | https://oxomi.com/p/3000126/datasheet/-/11600021001 | 0.011
1007464 | Tender Text en | Product URL DE | 15 | 25 | 0.00000516767 | REHAU Compression sleeve RAUTITAN PX 20 | 4007360361211 | 11600021001 | 1949 | https://oxomi.com/p/3000126/datasheet/-/11600021001 | 0.011
1007466 | Tender Text en | Product URL DE | 12 | 23.7 | 0.00000312848 | REHAU Compression sleeve RAUTITAN PX 16 | 4007360361204 | 11600011001 | 1947 | https://oxomi.com/p/3000126/datasheet/-/11600011001 | 0.0076
1007470 | Tender Text en | Product URL DE | 12 | 23.7 | 0.00000312848 | REHAU Compression sleeve RAUTITAN PX 16 | 4007360361204 | 11600011001 | 1947 | https://oxomi.com/p/3000126/datasheet/-/11600011001 | 0.0076
1007472 | Tender Text en | Product URL DE | 20 | 27.2 | 0.0000087028 | REHAU Compression sleeve RAUTITAN PX 25 | 4007360361228 | 11600031001 | 1950 | https://oxomi.com/p/3000126/datasheet/-/11600031001 | 0.015828
1007474 | Tender Text en | Product URL DE | 15 | 25 | 0.00000516767 | REHAU Compression sleeve RAUTITAN PX 20 | 4007360361211 | 11600021001 | 1949 | https://oxomi.com/p/3000126/datasheet/-/11600021001 | 0.011
1007476 | Tender Text en | Product URL DE | 20 | 27.2 | 0.0000087028 | REHAU Compression sleeve RAUTITAN PX 25 | 4007360361228 | 11600031001 | 1950 | https://oxomi.com/p/3000126/datasheet/-/11600031001 | 0.015828
1007478 | Tender Text en | Product URL DE | 25 | 34 | 0.0000174355 | REHAU Compression sleeve RAUTITAN PX 32 | 4007360361235 | 11600041001 | 1951 | https://oxomi.com/p/3000126/datasheet/-/11600041001 | 0.027828
1007480 | Tender Text en | Product URL DE | 20 | 27.2 | 0.0000087028 | REHAU Compression sleeve RAUTITAN PX 25 | 4007360361228 | 11600031001 | 1950 | https://oxomi.com/p/3000126/datasheet/-/11600031001 | 0.015828
1007482 | Tender Text en | Product URL DE | 25 | 34 | 0.0000174355 | REHAU Compression sleeve RAUTITAN PX 32 | 4007360361235 | 11600041001 | 1951 | https://oxomi.com/p/3000126/datasheet/-/11600041001 | 0.027828
1007484 | Tender Text en | Product URL DE | 32 | 37.8 | 0.0000303041 | REHAU Compression sleeve RAUTITAN PX 40 | 4007360361242 | 11600051001 | 1952 | https://oxomi.com/p/3000126/datasheet/-/11600051001 | 0.03861
1007486 | Tender Text en | Product URL DE | 25 | 34 | 0.0000174355 | REHAU Compression sleeve RAUTITAN PX 32 | 4007360361235 | 11600041001 | 1951 | https://oxomi.com/p/3000126/datasheet/-/11600041001 | 0.027828
1007488 | Tender Text en | Product URL DE | 32 | 37.8 | 0.0000303041 | REHAU Compression sleeve RAUTITAN PX 40 | 4007360361242 | 11600051001 | 1952 | https://oxomi.com/p/3000126/datasheet/-/11600051001 | 0.03861
1007492 | Tender Text en | Product URL DE | 32 | 37.8 | 0.0000303041 | REHAU Compression sleeve RAUTITAN PX 40 | 4007360361242 | 11600051001 | 1952 | https://oxomi.com/p/3000126/datasheet/-/11600051001 | 0.03861
1007502 | Tender Text en | Product URL DE | 15 | 25 | 0.00000516767 | REHAU Compression sleeve RAUTITAN PX 20 | 4007360361211 | 11600021001 | 1949 | https://oxomi.com/p/3000126/datasheet/-/11600021001 | 0.011
1007504 | Tender Text en | Product URL DE | 12 | 23.7 | 0.00000312848 | REHAU Compression sleeve RAUTITAN PX 16 | 4007360361204 | 11600011001 | 1947 | https://oxomi.com/p/3000126/datasheet/-/11600011001 | 0.0076
1007506 | Tender Text en | Product URL DE | 15 | 25 | 0.00000516767 | REHAU Compression sleeve RAUTITAN PX 20 | 4007360361211 | 11600021001 | 1949 | https://oxomi.com/p/3000126/datasheet/-/11600021001 | 0.011
1007508 | Tender Text en | Product URL DE | 20 | 27.2 | 0.0000087028 | REHAU Compression sleeve RAUTITAN PX 25 | 4007360361228 | 11600031001 | 1950 | https://oxomi.com/p/3000126/datasheet/-/11600031001 | 0.015828
1007510 | Tender Text en | Product URL DE | 12 | 23.7 | 0.00000312848 | REHAU Compression sleeve RAUTITAN PX 16 | 4007360361204 | 11600011001 | 1947 | https://oxomi.com/p/3000126/datasheet/-/11600011001 | 0.0076
1007512 | Tender Text en | Product URL DE | 20 | 27.2 | 0.0000087028 | REHAU Compression sleeve RAUTITAN PX 25 | 4007360361228 | 11600031001 | 1950 | https://oxomi.com/p/3000126/datasheet/-/11600031001 | 0.015828
1007514 | Tender Text en | Product URL DE | 25 | 34 | 0.0000174355 | REHAU Compression sleeve RAUTITAN PX 32 | 4007360361235 | 11600041001 | 1951 | https://oxomi.com/p/3000126/datasheet/-/11600041001 | 0.027828
1007516 | Tender Text en | Product URL DE | 15 | 25 | 0.00000516767 | REHAU Compression sleeve RAUTITAN PX 20 | 4007360361211 | 11600021001 | 1949 | https://oxomi.com/p/3000126/datasheet/-/11600021001 | 0.011
1007518 | Tender Text en | Product URL DE | 25 | 34 | 0.0000174355 | REHAU Compression sleeve RAUTITAN PX 32 | 4007360361235 | 11600041001 | 1951 | https://oxomi.com/p/3000126/datasheet/-/11600041001 | 0.027828
1007520 | Tender Text en | Product URL DE | 32 | 37.8 | 0.0000303041 | REHAU Compression sleeve RAUTITAN PX 40 | 4007360361242 | 11600051001 | 1952 | https://oxomi.com/p/3000126/datasheet/-/11600051001 | 0.03861
1007522 | Tender Text en | Product URL DE | 20 | 27.2 | 0.0000087028 | REHAU Compression sleeve RAUTITAN PX 25 | 4007360361228 | 11600031001 | 1950 | https://oxomi.com/p/3000126/datasheet/-/11600031001 | 0.015828
1007524 | Tender Text en | Product URL DE | 32 | 37.8 | 0.0000303041 | REHAU Compression sleeve RAUTITAN PX 40 | 4007360361242 | 11600051001 | 1952 | https://oxomi.com/p/3000126/datasheet/-/11600051001 | 0.03861
1007528 | Tender Text en | Product URL DE | 25 | 34 | 0.0000174355 | REHAU Compression sleeve RAUTITAN PX 32 | 4007360361235 | 11600041001 | 1951 | https://oxomi.com/p/3000126/datasheet/-/11600041001 | 0.027828
1007534 | Tender Text en | Product URL DE | 25 | 34 | 0.0000174355 | REHAU Compression sleeve RAUTITAN PX 32 | 4007360361235 | 11600041001 | 1951 | https://oxomi.com/p/3000126/datasheet/-/11600041001 | 0.027828
1007538 | Tender Text en | Product URL DE | 15 | 25 | 0.00000516767 | REHAU Compression sleeve RAUTITAN PX 20 | 4007360361211 | 11600021001 | 1949 | https://oxomi.com/p/3000126/datasheet/-/11600021001 | 0.011
1007542 | Tender Text en | Product URL DE | 15 | 25 | 0.00000516767 | REHAU Compression sleeve RAUTITAN PX 20 | 4007360361211 | 11600021001 | 1949 | https://oxomi.com/p/3000126/datasheet/-/11600021001 | 0.011
1007546 | Tender Text en | Product URL DE | 20 | 27.2 | 0.0000087028 | REHAU Compression sleeve RAUTITAN PX 25 | 4007360361228 | 11600031001 | 1950 | https://oxomi.com/p/3000126/datasheet/-/11600031001 | 0.015828
1007550 | Tender Text en | Product URL DE | 12 | 23.7 | 0.00000312848 | REHAU Compression sleeve RAUTITAN PX 16 | 4007360361204 | 11600011001 | 1947 | https://oxomi.com/p/3000126/datasheet/-/11600011001 | 0.0076
1007552 | Tender Text en | Product URL DE | 15 | 25 | 0.00000516767 | REHAU Compression sleeve RAUTITAN PX 20 | 4007360361211 | 11600021001 | 1949 | https://oxomi.com/p/3000126/datasheet/-/11600021001 | 0.011
1007554 | Tender Text en | Product URL DE | 12 | 23.7 | 0.00000312848 | REHAU Compression sleeve RAUTITAN PX 16 | 4007360361204 | 11600011001 | 1947 | https://oxomi.com/p/3000126/datasheet/-/11600011001 | 0.0076
1007556 | Tender Text en | Product URL DE | 15 | 25 | 0.00000516767 | REHAU Compression sleeve RAUTITAN PX 20 | 4007360361211 | 11600021001 | 1949 | https://oxomi.com/p/3000126/datasheet/-/11600021001 | 0.011
1007558 | Tender Text en | Product URL DE | 20 | 27.2 | 0.0000087028 | REHAU Compression sleeve RAUTITAN PX 25 | 4007360361228 | 11600031001 | 1950 | https://oxomi.com/p/3000126/datasheet/-/11600031001 | 0.015828
1007560 | Tender Text en | Product URL DE | 15 | 25 | 0.00000516767 | REHAU Compression sleeve RAUTITAN PX 20 | 4007360361211 | 11600021001 | 1949 | https://oxomi.com/p/3000126/datasheet/-/11600021001 | 0.011
1007562 | Tender Text en | Product URL DE | 12 | 23.7 | 0.00000312848 | REHAU Compression sleeve RAUTITAN PX 16 | 4007360361204 | 11600011001 | 1947 | https://oxomi.com/p/3000126/datasheet/-/11600011001 | 0.0076
1007568 | Tender Text en | Product URL DE | 20 | 27.2 | 0.0000087028 | REHAU Compression sleeve RAUTITAN PX 25 | 4007360361228 | 11600031001 | 1950 | https://oxomi.com/p/3000126/datasheet/-/11600031001 | 0.015828
1007570 | Tender Text en | Product URL DE | 15 | 25 | 0.00000516767 | REHAU Compression sleeve RAUTITAN PX 20 | 4007360361211 | 11600021001 | 1949 | https://oxomi.com/p/3000126/datasheet/-/11600021001 | 0.011
1007572 | Tender Text en | Product URL DE | 15 | 25 | 0.00000516767 | REHAU Compression sleeve RAUTITAN PX 20 | 4007360361211 | 11600021001 | 1949 | https://oxomi.com/p/3000126/datasheet/-/11600021001 | 0.011
1007574 | Tender Text en | Product URL DE | 25 | 34 | 0.0000174355 | REHAU Compression sleeve RAUTITAN PX 32 | 4007360361235 | 11600041001 | 1951 | https://oxomi.com/p/3000126/datasheet/-/11600041001 | 0.027828
1007576 | Tender Text en | Product URL DE | 20 | 27.2 | 0.0000087028 | REHAU Compression sleeve RAUTITAN PX 25 | 4007360361228 | 11600031001 | 1950 | https://oxomi.com/p/3000126/datasheet/-/11600031001 | 0.015828
1007578 | Tender Text en | Product URL DE | 20 | 27.2 | 0.0000087028 | REHAU Compression sleeve RAUTITAN PX 25 | 4007360361228 | 11600031001 | 1950 | https://oxomi.com/p/3000126/datasheet/-/11600031001 | 0.015828
1007580 | Tender Text en | Product URL DE | 32 | 37.8 | 0.0000303041 | REHAU Compression sleeve RAUTITAN PX 40 | 4007360361242 | 11600051001 | 1952 | https://oxomi.com/p/3000126/datasheet/-/11600051001 | 0.03861
1007582 | Tender Text en | Product URL DE | 25 | 34 | 0.0000174355 | REHAU Compression sleeve RAUTITAN PX 32 | 4007360361235 | 11600041001 | 1951 | https://oxomi.com/p/3000126/datasheet/-/11600041001 | 0.027828
1007584 | Tender Text en | Product URL DE | 25 | 34 | 0.0000174355 | REHAU Compression sleeve RAUTITAN PX 32 | 4007360361235 | 11600041001 | 1951 | https://oxomi.com/p/3000126/datasheet/-/11600041001 | 0.027828
1007586 | Tender Text en | Product URL DE | 15 | 25 | 0.00000516767 | REHAU Compression sleeve RAUTITAN PX 20 | 4007360361211 | 11600021001 | 1949 | https://oxomi.com/p/3000126/datasheet/-/11600021001 | 0.011
1007588 | Tender Text en | Product URL DE | 12 | 23.7 | 0.00000312848 | REHAU Compression sleeve RAUTITAN PX 16 | 4007360361204 | 11600011001 | 1947 | https://oxomi.com/p/3000126/datasheet/-/11600011001 | 0.0076
1007590 | Tender Text en | Product URL DE | 12 | 23.7 | 0.00000312848 | REHAU Compression sleeve RAUTITAN PX 16 | 4007360361204 | 11600011001 | 1947 | https://oxomi.com/p/3000126/datasheet/-/11600011001 | 0.0076
1007592 | Tender Text en | Product URL DE | 12 | 23.7 | 0.00000312848 | REHAU Compression sleeve RAUTITAN PX 16 | 4007360361204 | 11600011001 | 1947 | https://oxomi.com/p/3000126/datasheet/-/11600011001 | 0.0076
1007594 | Tender Text en | Product URL DE | 12 | 23.7 | 0.00000312848 | REHAU Compression sleeve RAUTITAN PX 16 | 4007360361204 | 11600011001 | 1947 | https://oxomi.com/p/3000126/datasheet/-/11600011001 | 0.0076
1007598 | Tender Text en | Product URL DE | 20 | 27.2 | 0.0000087028 | REHAU Compression sleeve RAUTITAN PX 25 | 4007360361228 | 11600031001 | 1950 | https://oxomi.com/p/3000126/datasheet/-/11600031001 | 0.015828
1007600 | Tender Text en | Product URL DE | 20 | 27.2 | 0.0000087028 | REHAU Compression sleeve RAUTITAN PX 25 | 4007360361228 | 11600031001 | 1950 | https://oxomi.com/p/3000126/datasheet/-/11600031001 | 0.015828
1007602 | Tender Text en | Product URL DE | 15 | 25 | 0.00000516767 | REHAU Compression sleeve RAUTITAN PX 20 | 4007360361211 | 11600021001 | 1949 | https://oxomi.com/p/3000126/datasheet/-/11600021001 | 0.011
1007604 | Tender Text en | Product URL DE | 25 | 34 | 0.0000174355 | REHAU Compression sleeve RAUTITAN PX 32 | 4007360361235 | 11600041001 | 1951 | https://oxomi.com/p/3000126/datasheet/-/11600041001 | 0.027828
1007606 | Tender Text en | Product URL DE | 25 | 34 | 0.0000174355 | REHAU Compression sleeve RAUTITAN PX 32 | 4007360361235 | 11600041001 | 1951 | https://oxomi.com/p/3000126/datasheet/-/11600041001 | 0.027828
1007608 | Tender Text en | Product URL DE | 20 | 27.2 | 0.0000087028 | REHAU Compression sleeve RAUTITAN PX 25 | 4007360361228 | 11600031001 | 1950 | https://oxomi.com/p/3000126/datasheet/-/11600031001 | 0.015828
1007610 | Tender Text en | Product URL DE | 15 | 25 | 0.00000516767 | REHAU Compression sleeve RAUTITAN PX 20 | 4007360361211 | 11600021001 | 1949 | https://oxomi.com/p/3000126/datasheet/-/11600021001 | 0.011
1007612 | Tender Text en | Product URL DE | 15 | 25 | 0.00000516767 | REHAU Compression sleeve RAUTITAN PX 20 | 4007360361211 | 11600021001 | 1949 | https://oxomi.com/p/3000126/datasheet/-/11600021001 | 0.011
1007614 | Tender Text en | Product URL DE | 12 | 23.7 | 0.00000312848 | REHAU Compression sleeve RAUTITAN PX 16 | 4007360361204 | 11600011001 | 1947 | https://oxomi.com/p/3000126/datasheet/-/11600011001 | 0.0076
1007618 | Tender Text en | Product URL DE | 25 | 34 | 0.0000174355 | REHAU Compression sleeve RAUTITAN PX 32 | 4007360361235 | 11600041001 | 1951 | https://oxomi.com/p/3000126/datasheet/-/11600041001 | 0.027828
1007620 | Tender Text en | Product URL DE | 32 | 37.8 | 0.0000303041 | REHAU Compression sleeve RAUTITAN PX 40 | 4007360361242 | 11600051001 | 1952 | https://oxomi.com/p/3000126/datasheet/-/11600051001 | 0.03861
1007622 | Tender Text en | Product URL DE | 20 | 27.2 | 0.0000087028 | REHAU Compression sleeve RAUTITAN PX 25 | 4007360361228 | 11600031001 | 1950 | https://oxomi.com/p/3000126/datasheet/-/11600031001 | 0.015828
1007624 | Tender Text en | Product URL DE | 20 | 27.2 | 0.0000087028 | REHAU Compression sleeve RAUTITAN PX 25 | 4007360361228 | 11600031001 | 1950 | https://oxomi.com/p/3000126/datasheet/-/11600031001 | 0.015828
1007626 | Tender Text en | Product URL DE | 12 | 23.7 | 0.00000312848 | REHAU Compression sleeve RAUTITAN PX 16 | 4007360361204 | 11600011001 | 1947 | https://oxomi.com/p/3000126/datasheet/-/11600011001 | 0.0076
1007628 | Tender Text en | Product URL DE | 25 | 34 | 0.0000174355 | REHAU Compression sleeve RAUTITAN PX 32 | 4007360361235 | 11600041001 | 1951 | https://oxomi.com/p/3000126/datasheet/-/11600041001 | 0.027828
1007630 | Tender Text en | Product URL DE | 15 | 25 | 0.00000516767 | REHAU Compression sleeve RAUTITAN PX 20 | 4007360361211 | 11600021001 | 1949 | https://oxomi.com/p/3000126/datasheet/-/11600021001 | 0.011
1007632 | Tender Text en | Product URL DE | 20 | 27.2 | 0.0000087028 | REHAU Compression sleeve RAUTITAN PX 25 | 4007360361228 | 11600031001 | 1950 | https://oxomi.com/p/3000126/datasheet/-/11600031001 | 0.015828
1078155 | Tender Text nl | Product URL NL | 12 | 23.7 | 0.00000312848 | REHAU Compression sleeve RAUTITAN PX 16 | 4007360361204 | 11600011001 | 1947 | https://oxomi.com/p/3001042/datasheet/-/11600011001 | 0.0076
1078159 | Tender Text nl | Product URL NL | 15 | 25 | 0.00000516767 | REHAU Compression sleeve RAUTITAN PX 20 | 4007360361211 | 11600021001 | 1949 | https://oxomi.com/p/3001042/datasheet/-/11600021001 | 0.011
1078476 | Tender Text en | Product URL DE | 12 | 23.7 | 0.00000312848 | REHAU Compression sleeve RAUTITAN PX 16 | 4007360361204 | 11600011001 | 1947 | https://oxomi.com/p/3000126/datasheet/-/11600011001 | 0.0076
1078478 | Tender Text en | Product URL DE | 12 | 23.7 | 0.00000312848 | REHAU Compression sleeve RAUTITAN PX 16 | 4007360361204 | 11600011001 | 1947 | https://oxomi.com/p/3000126/datasheet/-/11600011001 | 0.0076
1078480 | Tender Text en | Product URL DE | 15 | 25 | 0.00000516767 | REHAU Compression sleeve RAUTITAN PX 20 | 4007360361211 | 11600021001 | 1949 | https://oxomi.com/p/3000126/datasheet/-/11600021001 | 0.011
1078482 | Tender Text en | Product URL DE | 15 | 25 | 0.00000516767 | REHAU Compression sleeve RAUTITAN PX 20 | 4007360361211 | 11600021001 | 1949 | https://oxomi.com/p/3000126/datasheet/-/11600021001 | 0.011
1078484 | Tender Text en | Product URL DE | 20 | 27.2 | 0.0000087028 | REHAU Compression sleeve RAUTITAN PX 25 | 4007360361228 | 11600031001 | 1950 | https://oxomi.com/p/3000126/datasheet/-/11600031001 | 0.015828
1078486 | Tender Text en | Product URL DE | 20 | 27.2 | 0.0000087028 | REHAU Compression sleeve RAUTITAN PX 25 | 4007360361228 | 11600031001 | 1950 | https://oxomi.com/p/3000126/datasheet/-/11600031001 | 0.015828
1078488 | Tender Text en | Product URL DE | 25 | 34 | 0.0000174355 | REHAU Compression sleeve RAUTITAN PX 32 | 4007360361235 | 11600041001 | 1951 | https://oxomi.com/p/3000126/datasheet/-/11600041001 | 0.027828
1078490 | Tender Text en | Product URL DE | 25 | 34 | 0.0000174355 | REHAU Compression sleeve RAUTITAN PX 32 | 4007360361235 | 11600041001 | 1951 | https://oxomi.com/p/3000126/datasheet/-/11600041001 | 0.027828
1078492 | Tender Text en | Product URL DE | 32 | 37.8 | 0.0000303041 | REHAU Compression sleeve RAUTITAN PX 40 | 4007360361242 | 11600051001 | 1952 | https://oxomi.com/p/3000126/datasheet/-/11600051001 | 0.03861
1078494 | Tender Text en | Product URL DE | 32 | 37.8 | 0.0000303041 | REHAU Compression sleeve RAUTITAN PX 40 | 4007360361242 | 11600051001 | 1952 | https://oxomi.com/p/3000126/datasheet/-/11600051001 | 0.03861
1078496 | Tender Text en | Product URL DE | 15 | 25 | 0.00000516767 | REHAU Compression sleeve RAUTITAN PX 20 | 4007360361211 | 11600021001 | 1949 | https://oxomi.com/p/3000126/datasheet/-/11600021001 | 0.011
1078498 | Tender Text en | Product URL DE | 15 | 25 | 0.00000516767 | REHAU Compression sleeve RAUTITAN PX 20 | 4007360361211 | 11600021001 | 1949 | https://oxomi.com/p/3000126/datasheet/-/11600021001 | 0.011
1078500 | Tender Text en | Product URL DE | 20 | 27.2 | 0.0000087028 | REHAU Compression sleeve RAUTITAN PX 25 | 4007360361228 | 11600031001 | 1950 | https://oxomi.com/p/3000126/datasheet/-/11600031001 | 0.015828
1078502 | Tender Text en | Product URL DE | 20 | 27.2 | 0.0000087028 | REHAU Compression sleeve RAUTITAN PX 25 | 4007360361228 | 11600031001 | 1950 | https://oxomi.com/p/3000126/datasheet/-/11600031001 | 0.015828
1078504 | Tender Text en | Product URL DE | 25 | 34 | 0.0000174355 | REHAU Compression sleeve RAUTITAN PX 32 | 4007360361235 | 11600041001 | 1951 | https://oxomi.com/p/3000126/datasheet/-/11600041001 | 0.027828
1078506 | Tender Text en | Product URL DE | 25 | 34 | 0.0000174355 | REHAU Compression sleeve RAUTITAN PX 32 | 4007360361235 | 11600041001 | 1951 | https://oxomi.com/p/3000126/datasheet/-/11600041001 | 0.027828
1078508 | Tender Text en | Product URL DE | 32 | 37.8 | 0.0000303041 | REHAU Compression sleeve RAUTITAN PX 40 | 4007360361242 | 11600051001 | 1952 | https://oxomi.com/p/3000126/datasheet/-/11600051001 | 0.03861
1078510 | Tender Text en | Product URL DE | 32 | 37.8 | 0.0000303041 | REHAU Compression sleeve RAUTITAN PX 40 | 4007360361242 | 11600051001 | 1952 | https://oxomi.com/p/3000126/datasheet/-/11600051001 | 0.03861
1078512 | Tender Text en | Product URL DE | 40 | 45 | 0.0000353695 | REHAU Compr. sleeve RAUTITAN PX stabil 50 | 4062178755416 | 11602061001 | 1954 | https://oxomi.com/p/3000126/datasheet/-/11602061001 | 0.0673
1078514 | Tender Text en | Product URL DE | 40 | 45 | 0.0000353695 | REHAU Compr. sleeve RAUTITAN PX stabil 50 | 4062178755416 | 11602061001 | 1954 | https://oxomi.com/p/3000126/datasheet/-/11602061001 | 0.0673
1078516 | Tender Text en | Product URL DE | 50 | 53 | 0.0000702282 | REHAU Compr. sleeve RAUTITAN PX stabil 63 | 4062178755423 | 11602071001 | 1955 | https://oxomi.com/p/3000126/datasheet/-/11602071001 | 0.1106
1078518 | Tender Text en | Product URL DE | 50 | 53 | 0.0000702282 | REHAU Compr. sleeve RAUTITAN PX stabil 63 | 4062178755423 | 11602071001 | 1955 | https://oxomi.com/p/3000126/datasheet/-/11602071001 | 0.1106
1078520 | Tender Text en | Product URL DE | 50 | 53 | 0.0000702282 | REHAU Compr. sleeve RAUTITAN PX stabil 63 | 4062178755423 | 11602071001 | 1955 | https://oxomi.com/p/3000126/datasheet/-/11602071001 | 0.1106
1078522 | Tender Text en | Product URL DE | 50 | 53 | 0.0000702282 | REHAU Compr. sleeve RAUTITAN PX stabil 63 | 4062178755423 | 11602071001 | 1955 | https://oxomi.com/p/3000126/datasheet/-/11602071001 | 0.1106
1078524 | Tender Text en | Product URL DE | 40 | 45 | 0.0000353695 | REHAU Compr. sleeve RAUTITAN PX stabil 50 | 4062178755416 | 11602061001 | 1954 | https://oxomi.com/p/3000126/datasheet/-/11602061001 | 0.0673
1078526 | Tender Text en | Product URL DE | 40 | 45 | 0.0000353695 | REHAU Compr. sleeve RAUTITAN PX stabil 50 | 4062178755416 | 11602061001 | 1954 | https://oxomi.com/p/3000126/datasheet/-/11602061001 | 0.0673
1078528 | Tender Text en | Product URL DE | 12 | 23.7 | 0.00000312848 | REHAU Compression sleeve RAUTITAN PX 16 | 4007360361204 | 11600011001 | 1947 | https://oxomi.com/p/3000126/datasheet/-/11600011001 | 0.0076
1078530 | Tender Text en | Product URL DE | 12 | 23.7 | 0.00000312848 | REHAU Compression sleeve RAUTITAN PX 16 | 4007360361204 | 11600011001 | 1947 | https://oxomi.com/p/3000126/datasheet/-/11600011001 | 0.0076
1078532 | Tender Text en | Product URL DE | 15 | 25 | 0.00000516767 | REHAU Compression sleeve RAUTITAN PX 20 | 4007360361211 | 11600021001 | 1949 | https://oxomi.com/p/3000126/datasheet/-/11600021001 | 0.011
1078534 | Tender Text en | Product URL DE | 15 | 25 | 0.00000516767 | REHAU Compression sleeve RAUTITAN PX 20 | 4007360361211 | 11600021001 | 1949 | https://oxomi.com/p/3000126/datasheet/-/11600021001 | 0.011
1078536 | Tender Text en | Product URL DE | 20 | 27.2 | 0.0000087028 | REHAU Compression sleeve RAUTITAN PX 25 | 4007360361228 | 11600031001 | 1950 | https://oxomi.com/p/3000126/datasheet/-/11600031001 | 0.015828
1078538 | Tender Text en | Product URL DE | 20 | 27.2 | 0.0000087028 | REHAU Compression sleeve RAUTITAN PX 25 | 4007360361228 | 11600031001 | 1950 | https://oxomi.com/p/3000126/datasheet/-/11600031001 | 0.015828
1078540 | Tender Text en | Product URL DE | 25 | 34 | 0.0000174355 | REHAU Compression sleeve RAUTITAN PX 32 | 4007360361235 | 11600041001 | 1951 | https://oxomi.com/p/3000126/datasheet/-/11600041001 | 0.027828
1078542 | Tender Text en | Product URL DE | 25 | 34 | 0.0000174355 | REHAU Compression sleeve RAUTITAN PX 32 | 4007360361235 | 11600041001 | 1951 | https://oxomi.com/p/3000126/datasheet/-/11600041001 | 0.027828
1078562 | Tender Text nl | Product URL NL | 15 | 25 | 0.00000516767 | REHAU Compression sleeve RAUTITAN PX 20 | 4007360361211 | 11600021001 | 1949 | https://oxomi.com/p/3001042/datasheet/-/11600021001 | 0.011
1078566 | Tender Text nl | Product URL NL | 20 | 27.2 | 0.0000087028 | REHAU Compression sleeve RAUTITAN PX 25 | 4007360361228 | 11600031001 | 1950 | https://oxomi.com/p/3001042/datasheet/-/11600031001 | 0.015828
1078569 | Tender Text en | Product URL DE | 12 | 23.7 | 0.00000312848 | REHAU Compression sleeve RAUTITAN PX 16 | 4007360361204 | 11600011001 | 1947 | https://oxomi.com/p/3000126/datasheet/-/11600011001 | 0.0076
1078571 | Tender Text en | Product URL DE | 12 | 23.7 | 0.00000312848 | REHAU Compression sleeve RAUTITAN PX 16 | 4007360361204 | 11600011001 | 1947 | https://oxomi.com/p/3000126/datasheet/-/11600011001 | 0.0076
1078573 | Tender Text en | Product URL DE | 12 | 23.7 | 0.00000312848 | REHAU Compression sleeve RAUTITAN PX 16 | 4007360361204 | 11600011001 | 1947 | https://oxomi.com/p/3000126/datasheet/-/11600011001 | 0.0076
1078575 | Tender Text en | Product URL DE | 20 | 27.2 | 0.0000087028 | REHAU Compression sleeve RAUTITAN PX 25 | 4007360361228 | 11600031001 | 1950 | https://oxomi.com/p/3000126/datasheet/-/11600031001 | 0.015828
1078577 | Tender Text en | Product URL DE | 20 | 27.2 | 0.0000087028 | REHAU Compression sleeve RAUTITAN PX 25 | 4007360361228 | 11600031001 | 1950 | https://oxomi.com/p/3000126/datasheet/-/11600031001 | 0.015828
1078579 | Tender Text en | Product URL DE | 20 | 27.2 | 0.0000087028 | REHAU Compression sleeve RAUTITAN PX 25 | 4007360361228 | 11600031001 | 1950 | https://oxomi.com/p/3000126/datasheet/-/11600031001 | 0.015828
1078581 | Tender Text en | Product URL DE | 25 | 34 | 0.0000174355 | REHAU Compression sleeve RAUTITAN PX 32 | 4007360361235 | 11600041001 | 1951 | https://oxomi.com/p/3000126/datasheet/-/11600041001 | 0.027828
1078583 | Tender Text en | Product URL DE | 25 | 34 | 0.0000174355 | REHAU Compression sleeve RAUTITAN PX 32 | 4007360361235 | 11600041001 | 1951 | https://oxomi.com/p/3000126/datasheet/-/11600041001 | 0.027828
1078585 | Tender Text en | Product URL DE | 25 | 34 | 0.0000174355 | REHAU Compression sleeve RAUTITAN PX 32 | 4007360361235 | 11600041001 | 1951 | https://oxomi.com/p/3000126/datasheet/-/11600041001 | 0.027828
1078587 | Tender Text en | Product URL DE | 32 | 37.8 | 0.0000303041 | REHAU Compression sleeve RAUTITAN PX 40 | 4007360361242 | 11600051001 | 1952 | https://oxomi.com/p/3000126/datasheet/-/11600051001 | 0.03861
1078589 | Tender Text en | Product URL DE | 32 | 37.8 | 0.0000303041 | REHAU Compression sleeve RAUTITAN PX 40 | 4007360361242 | 11600051001 | 1952 | https://oxomi.com/p/3000126/datasheet/-/11600051001 | 0.03861
1078591 | Tender Text en | Product URL DE | 32 | 37.8 | 0.0000303041 | REHAU Compression sleeve RAUTITAN PX 40 | 4007360361242 | 11600051001 | 1952 | https://oxomi.com/p/3000126/datasheet/-/11600051001 | 0.03861
1078593 | Tender Text en | Product URL DE | 15 | 25 | 0.00000516767 | REHAU Compression sleeve RAUTITAN PX 20 | 4007360361211 | 11600021001 | 1949 | https://oxomi.com/p/3000126/datasheet/-/11600021001 | 0.011
1078595 | Tender Text en | Product URL DE | 15 | 25 | 0.00000516767 | REHAU Compression sleeve RAUTITAN PX 20 | 4007360361211 | 11600021001 | 1949 | https://oxomi.com/p/3000126/datasheet/-/11600021001 | 0.011
1078597 | Tender Text en | Product URL DE | 15 | 25 | 0.00000516767 | REHAU Compression sleeve RAUTITAN PX 20 | 4007360361211 | 11600021001 | 1949 | https://oxomi.com/p/3000126/datasheet/-/11600021001 | 0.011
1078599 | Tender Text en | Product URL DE | 20 | 27.2 | 0.0000087028 | REHAU Compression sleeve RAUTITAN PX 25 | 4007360361228 | 11600031001 | 1950 | https://oxomi.com/p/3000126/datasheet/-/11600031001 | 0.015828
1078601 | Tender Text en | Product URL DE | 15 | 25 | 0.00000516767 | REHAU Compression sleeve RAUTITAN PX 20 | 4007360361211 | 11600021001 | 1949 | https://oxomi.com/p/3000126/datasheet/-/11600021001 | 0.011
1078603 | Tender Text en | Product URL DE | 20 | 27.2 | 0.0000087028 | REHAU Compression sleeve RAUTITAN PX 25 | 4007360361228 | 11600031001 | 1950 | https://oxomi.com/p/3000126/datasheet/-/11600031001 | 0.015828
1078605 | Tender Text en | Product URL DE | 25 | 34 | 0.0000174355 | REHAU Compression sleeve RAUTITAN PX 32 | 4007360361235 | 11600041001 | 1951 | https://oxomi.com/p/3000126/datasheet/-/11600041001 | 0.027828
1078607 | Tender Text en | Product URL DE | 20 | 27.2 | 0.0000087028 | REHAU Compression sleeve RAUTITAN PX 25 | 4007360361228 | 11600031001 | 1950 | https://oxomi.com/p/3000126/datasheet/-/11600031001 | 0.015828
1078609 | Tender Text en | Product URL DE | 25 | 34 | 0.0000174355 | REHAU Compression sleeve RAUTITAN PX 32 | 4007360361235 | 11600041001 | 1951 | https://oxomi.com/p/3000126/datasheet/-/11600041001 | 0.027828
1078611 | Tender Text en | Product URL DE | 32 | 37.8 | 0.0000303041 | REHAU Compression sleeve RAUTITAN PX 40 | 4007360361242 | 11600051001 | 1952 | https://oxomi.com/p/3000126/datasheet/-/11600051001 | 0.03861
1078613 | Tender Text en | Product URL DE | 25 | 34 | 0.0000174355 | REHAU Compression sleeve RAUTITAN PX 32 | 4007360361235 | 11600041001 | 1951 | https://oxomi.com/p/3000126/datasheet/-/11600041001 | 0.027828
1078615 | Tender Text en | Product URL DE | 32 | 37.8 | 0.0000303041 | REHAU Compression sleeve RAUTITAN PX 40 | 4007360361242 | 11600051001 | 1952 | https://oxomi.com/p/3000126/datasheet/-/11600051001 | 0.03861
1078617 | Tender Text en | Product URL DE | 15 | 25 | 0.00000516767 | REHAU Compression sleeve RAUTITAN PX 20 | 4007360361211 | 11600021001 | 1949 | https://oxomi.com/p/3000126/datasheet/-/11600021001 | 0.011
1078619 | Tender Text en | Product URL DE | 12 | 23.7 | 0.00000312848 | REHAU Compression sleeve RAUTITAN PX 16 | 4007360361204 | 11600011001 | 1947 | https://oxomi.com/p/3000126/datasheet/-/11600011001 | 0.0076
1078621 | Tender Text en | Product URL DE | 15 | 25 | 0.00000516767 | REHAU Compression sleeve RAUTITAN PX 20 | 4007360361211 | 11600021001 | 1949 | https://oxomi.com/p/3000126/datasheet/-/11600021001 | 0.011
1078623 | Tender Text en | Product URL DE | 20 | 27.2 | 0.0000087028 | REHAU Compression sleeve RAUTITAN PX 25 | 4007360361228 | 11600031001 | 1950 | https://oxomi.com/p/3000126/datasheet/-/11600031001 | 0.015828
1078625 | Tender Text en | Product URL DE | 12 | 23.7 | 0.00000312848 | REHAU Compression sleeve RAUTITAN PX 16 | 4007360361204 | 11600011001 | 1947 | https://oxomi.com/p/3000126/datasheet/-/11600011001 | 0.0076
1078627 | Tender Text en | Product URL DE | 20 | 27.2 | 0.0000087028 | REHAU Compression sleeve RAUTITAN PX 25 | 4007360361228 | 11600031001 | 1950 | https://oxomi.com/p/3000126/datasheet/-/11600031001 | 0.015828
1078629 | Tender Text en | Product URL DE | 25 | 34 | 0.0000174355 | REHAU Compression sleeve RAUTITAN PX 32 | 4007360361235 | 11600041001 | 1951 | https://oxomi.com/p/3000126/datasheet/-/11600041001 | 0.027828
1078631 | Tender Text en | Product URL DE | 15 | 25 | 0.00000516767 | REHAU Compression sleeve RAUTITAN PX 20 | 4007360361211 | 11600021001 | 1949 | https://oxomi.com/p/3000126/datasheet/-/11600021001 | 0.011
1078633 | Tender Text en | Product URL DE | 25 | 34 | 0.0000174355 | REHAU Compression sleeve RAUTITAN PX 32 | 4007360361235 | 11600041001 | 1951 | https://oxomi.com/p/3000126/datasheet/-/11600041001 | 0.027828
1078635 | Tender Text en | Product URL DE | 32 | 37.8 | 0.0000303041 | REHAU Compression sleeve RAUTITAN PX 40 | 4007360361242 | 11600051001 | 1952 | https://oxomi.com/p/3000126/datasheet/-/11600051001 | 0.03861
1078637 | Tender Text en | Product URL DE | 20 | 27.2 | 0.0000087028 | REHAU Compression sleeve RAUTITAN PX 25 | 4007360361228 | 11600031001 | 1950 | https://oxomi.com/p/3000126/datasheet/-/11600031001 | 0.015828
1078639 | Tender Text en | Product URL DE | 32 | 37.8 | 0.0000303041 | REHAU Compression sleeve RAUTITAN PX 40 | 4007360361242 | 11600051001 | 1952 | https://oxomi.com/p/3000126/datasheet/-/11600051001 | 0.03861
1078641 | Tender Text en | Product URL DE | 25 | 34 | 0.0000174355 | REHAU Compression sleeve RAUTITAN PX 32 | 4007360361235 | 11600041001 | 1951 | https://oxomi.com/p/3000126/datasheet/-/11600041001 | 0.027828
1078643 | Tender Text en | Product URL DE | 12 | 23.7 | 0.00000312848 | REHAU Compression sleeve RAUTITAN PX 16 | 4007360361204 | 11600011001 | 1947 | https://oxomi.com/p/3000126/datasheet/-/11600011001 | 0.0076
1078645 | Tender Text en | Product URL DE | 25 | 34 | 0.0000174355 | REHAU Compression sleeve RAUTITAN PX 32 | 4007360361235 | 11600041001 | 1951 | https://oxomi.com/p/3000126/datasheet/-/11600041001 | 0.027828
1078647 | Tender Text en | Product URL DE | 32 | 37.8 | 0.0000303041 | REHAU Compression sleeve RAUTITAN PX 40 | 4007360361242 | 11600051001 | 1952 | https://oxomi.com/p/3000126/datasheet/-/11600051001 | 0.03861
1078649 | Tender Text en | Product URL DE | 15 | 25 | 0.00000516767 | REHAU Compression sleeve RAUTITAN PX 20 | 4007360361211 | 11600021001 | 1949 | https://oxomi.com/p/3000126/datasheet/-/11600021001 | 0.011
1078651 | Tender Text en | Product URL DE | 32 | 37.8 | 0.0000303041 | REHAU Compression sleeve RAUTITAN PX 40 | 4007360361242 | 11600051001 | 1952 | https://oxomi.com/p/3000126/datasheet/-/11600051001 | 0.03861
1078653 | Tender Text en | Product URL DE | 12 | 23.7 | 0.00000312848 | REHAU Compression sleeve RAUTITAN PX 16 | 4007360361204 | 11600011001 | 1947 | https://oxomi.com/p/3000126/datasheet/-/11600011001 | 0.0076
1078655 | Tender Text en | Product URL DE | 15 | 25 | 0.00000516767 | REHAU Compression sleeve RAUTITAN PX 20 | 4007360361211 | 11600021001 | 1949 | https://oxomi.com/p/3000126/datasheet/-/11600021001 | 0.011
1078657 | Tender Text en | Product URL DE | 12 | 23.7 | 0.00000312848 | REHAU Compression sleeve RAUTITAN PX 16 | 4007360361204 | 11600011001 | 1947 | https://oxomi.com/p/3000126/datasheet/-/11600011001 | 0.0076
1078659 | Tender Text en | Product URL DE | 20 | 27.2 | 0.0000087028 | REHAU Compression sleeve RAUTITAN PX 25 | 4007360361228 | 11600031001 | 1950 | https://oxomi.com/p/3000126/datasheet/-/11600031001 | 0.015828
1078661 | Tender Text en | Product URL DE | 25 | 34 | 0.0000174355 | REHAU Compression sleeve RAUTITAN PX 32 | 4007360361235 | 11600041001 | 1951 | https://oxomi.com/p/3000126/datasheet/-/11600041001 | 0.027828
1078663 | Tender Text en | Product URL DE | 20 | 27.2 | 0.0000087028 | REHAU Compression sleeve RAUTITAN PX 25 | 4007360361228 | 11600031001 | 1950 | https://oxomi.com/p/3000126/datasheet/-/11600031001 | 0.015828
1078665 | Tender Text en | Product URL DE | 15 | 25 | 0.00000516767 | REHAU Compression sleeve RAUTITAN PX 20 | 4007360361211 | 11600021001 | 1949 | https://oxomi.com/p/3000126/datasheet/-/11600021001 | 0.011
1078667 | Tender Text en | Product URL DE | 20 | 27.2 | 0.0000087028 | REHAU Compression sleeve RAUTITAN PX 25 | 4007360361228 | 11600031001 | 1950 | https://oxomi.com/p/3000126/datasheet/-/11600031001 | 0.015828
