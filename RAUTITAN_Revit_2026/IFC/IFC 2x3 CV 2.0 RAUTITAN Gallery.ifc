Properties of the parts of a building model (IFC2X3), part 6 of 9

# IfcFlowFitting: REHAU_RAUTITAN_Cap_RX+:REHAU_RAUTITAN_Cap_RX+ (2)
Type - Other - Category: Pipe Fittings; Family Name: REHAU_RAUTITAN_Cap_RX+
Type - Constraints - Default Elevation: 0 mm
Type - Identity Data - REH_PRICE_LIST: DE_2023; REH_PRODUCT_PICTURE: https://static.rehau.com/bim/images/1000/jpg/M-52487.jpg; Type Name: REHAU_RAUTITAN_Cap_RX+
Type - Materials and Finishes - REH_MATERIAL: RX
Pset_DistributionFlowElementCommon - Reference: REHAU_RAUTITAN_Cap_RX+:REHAU_RAUTITAN_Cap_RX+; sets with these values: 2
Other - Family: REHAU_RAUTITAN_Cap_RX+; Family and Type: REHAU_RAUTITAN_Cap_RX+: REHAU_RAUTITAN_Cap_RX+; Type: REHAU_RAUTITAN_Cap_RX+; Type Id: 1089323
Constraints - Elevation from Level: 0 mm; Level: REHAU Starting view
Dimensions - Area: 0.0041524 m2
Graphics - Use Annotation Scale: no
Identity Data - REH_DESCRIPTION_LANGUAGE: Language : EN; ETIM_CLASS: EC003023; ETIM_MODELLING_CLASS: N/A; REH_BIM_SUPPORT: bim@rehau.com; REH_INFO: 2023.12.05-419114-419114
Mechanical - System Classification: Undefined
Phasing - Phase Created: New Construction
Insulation - Insulation Thickness: 0 mm
Name (REHAU_RAUTITAN_Cap_RX+:REHAU_RAUTITAN_Cap_RX+:...) | Nominal Diameter 1 (mm) = DN1 (mm) = Do1 (mm) = Maximum Size (mm) = Minimum Size (mm) | Dr2 (mm) | L1 (mm) | Size = Overall Size | SW (mm) | Volume (m3) | PID = REH_SUPPLIER_PID | REH_DESCRIPTION_SHORT | REH_DIMENSION | REH_GTIN | REH_NETWEIGHT_G/PC | REH_NOMINAL_DIAMETER
1444910 | 15 | 26.68 | 21.5 | 15 mmø | 25 | 0.00000493568 | 14563911001 | REHAU Cap RAUTITAN RX+ 16 - Rp 1/2 | 12 | 4061264398056 | 44 | DN 12
1445018 | 20 | 33 | 23 | 20 mmø | 31 | 0.00000755358 | 14563921001 | REHAU Cap RAUTITAN RX+ 20 - Rp 3/4 | 15 | 4061264398063 | 65 | DN 15

# IfcFlowFitting: REHAU_RAUTITAN_Compression sleeve manifold 2-port:REHAU_RAUTITAN_Compression sleeve manifold 2-port (2)
In: REHAU Starting view
Type - Material: RX
Type - Other - Category: Pipe Fittings; Family Name: REHAU_RAUTITAN_Compression sleeve manifold 2-port
Type - Constraints - Default Elevation: 0 mm
Type - Identity Data - ETIM_CLASS: EC003885; ETIM_MODELLING_CLASS: N/A; REH_BIM_SUPPORT: bim@rehau.com; REH_INFO: 2023.09.26-419114-419114; REH_PRICE_LIST: DE_2023; REH_PRODUCT_PICTURE: https://static.rehau.com/bim/images/1000/jpg/M-52481.jpg; Type Name: REHAU_RAUTITAN_Compression sleeve manifold 2-port
Type - Materials and Finishes - REH_MATERIAL: RX
Pset_DistributionFlowElementCommon - Reference: REHAU_RAUTITAN_Compression sleeve manifold 2-port:REHAU_RAUTITAN_Compression sleeve manifold 2-port; sets with these values: 2
Other - IsCustom: no; d: 50 mm; Family: REHAU_RAUTITAN_Compression sleeve manifold 2-port; Family and Type: REHAU_RAUTITAN_Compression sleeve manifold 2-port: REHAU_RAUTITAN_Compression sleeve manifold 2-port; Type: REHAU_RAUTITAN_Compression sleeve manifold 2-port; Type Id: 1089325
Constraints - Elevation from Level: 0 mm; Level: REHAU Starting view
Construction - Nominal Diameter 3: 20 mm; Nominal Diameter 4: 20 mm
Dimensions - Area: 0.0041524 m2; DN3: 20 mm; DN4: 20 mm; Maximum Size: 20 mm; SW: 32 mm
Graphics - Use Annotation Scale: no
Identity Data - REH_DESCRIPTION_LANGUAGE: Language : EN; REH_GTIN: 4060000000000
Mechanical - System Classification: Undefined
Phasing - Phase Created: New Construction
Insulation - Insulation Thickness: 0 mm
Name (REHAU_RAUTITAN_Compression sleeve manifold 2-port:REHAU_RAUTITAN_Compression sleeve manifold 2-port:...) | Nominal Diameter 1 (mm) = Nominal Diameter 2 (mm) = DN1 (mm) = DN2 (mm) = Minimum Size (mm) | Do1 (mm) = Do2 (mm) | Dr1 (mm) = Dr2 (mm) | h (mm) | L1 (mm) = L2 (mm) | Size = Overall Size | t1 (mm) = t2 (mm) | Volume (m3) | Z1 (mm) = Z2 (mm) | PID = REH_SUPPLIER_PID | REH_DESCRIPTION_SHORT | REH_DIMENSION | REH_NETWEIGHT_G/PC | REH_NOMINAL_DIAMETER
1444912 | 12 | 16 | 22.5 | 9.25 | 43.5 | 20 mmø-20 mmø-12 mmø-12 mmø | 3.79 | 0.0000339328 | 28 | 14563831001 | REHAU Compression sleeve manifold 2-port, 16 - R/Rp 3/4 | 2-fach, 16 - R/Rp 3/4 | 302 | DN 12/12/20/20
1445028 | 15 | 20 | 26.5 | 12 | 48.6 | 20 mmø-20 mmø-15 mmø-15 mmø | 4.3 | 0.0000373987 | 29.1 | 14563841001 | REHAU Compression sleeve manifold 2-port, 20 - R/Rp 3/4 | 2-fach, 20 - R/Rp 3/4 | 331 | DN 15/15/20/20

# IfcFlowFitting: REHAU_RAUTITAN_Compression sleeve manifold 3-port:REHAU_RAUTITAN_Compression sleeve manifold 3-port (2)
In: REHAU Starting view
Type - Material: RX
Type - Other - Category: Pipe Fittings; Family Name: REHAU_RAUTITAN_Compression sleeve manifold 3-port
Type - Constraints - Default Elevation: 0 mm
Type - Identity Data - ETIM_CLASS: EC003885; ETIM_MODELLING_CLASS: N/A; REH_BIM_SUPPORT: bim@rehau.com; REH_INFO: 2023.10.04-419114-416508; REH_PRICE_LIST: DE_2023; REH_PRODUCT_PICTURE: https://static.rehau.com/bim/images/1000/jpg/M-52483.jpg; Type Name: REHAU_RAUTITAN_Compression sleeve manifold 3-port
Type - Materials and Finishes - REH_MATERIAL: RX
Pset_DistributionFlowElementCommon - Reference: REHAU_RAUTITAN_Compression sleeve manifold 3-port:REHAU_RAUTITAN_Compression sleeve manifold 3-port; sets with these values: 2
Other - IsCustom: no; d: 50 mm; Family: REHAU_RAUTITAN_Compression sleeve manifold 3-port; Family and Type: REHAU_RAUTITAN_Compression sleeve manifold 3-port: REHAU_RAUTITAN_Compression sleeve manifold 3-port; Type: REHAU_RAUTITAN_Compression sleeve manifold 3-port; Type Id: 1089327
Constraints - Elevation from Level: 0 mm; Level: REHAU Starting view
Construction - Nominal Diameter 4: 20 mm; Nominal Diameter 5: 20 mm
Dimensions - Area: 0.0041524 m2; DN4: 20 mm; DN5: 20 mm; h: 12 mm; Maximum Size: 20 mm; SW: 32 mm
Graphics - Use Annotation Scale: no
Identity Data - REH_DESCRIPTION_LANGUAGE: Language : EN; REH_GTIN: 4061264397998
Mechanical - System Classification: Undefined
Phasing - Phase Created: New Construction
Insulation - Insulation Thickness: 0 mm
Name (REHAU_RAUTITAN_Compression sleeve manifold 3-port:REHAU_RAUTITAN_Compression sleeve manifold 3-port:...) | Nominal Diameter 1 (mm) = Nominal Diameter 2 (mm) = Nominal Diameter 3 (mm) = DN1 (mm) = DN2 (mm) = DN3 (mm) = Minimum Size (mm) | Do1 (mm) = Do2 (mm) = Do3 (mm) | Dr1 (mm) = Dr2 (mm) = Dr3 (mm) | L1 (mm) | L2 (mm) | L3 (mm) | Size = Overall Size | t1 (mm) = t2 (mm) = t3 (mm) | Volume (m3) | Z1 (mm) | Z2 (mm) | Z3 (mm) | PID = REH_SUPPLIER_PID | REH_DESCRIPTION_SHORT | REH_DIMENSION | REH_NETWEIGHT_G/PC | REH_NOMINAL_DIAMETER
1444918 | 12 | 16 | 22.5 | 43.5 | 43.5 | 43.5 | 20 mmø-20 mmø-12 mmø-12 mmø-12 mmø | 3.88 | 0.0000491228 | 28 | 28 | 28 | 14563851001 | REHAU Compression sleeve manifold 3-port, 16 - R/Rp 3/4 | 3-fach, 16 - R/Rp 3/4 | 425 | DN 12/12/12/20/20
1445020 | 15 | 20 | 26.5 | 48.66 | 48.31 | 48.5 | 20 mmø-20 mmø-15 mmø-15 mmø-15 mmø | 4.3 | 0.0000511437 | 29.61 | 28.81 | 29 | 14563861001 | REHAU Compression sleeve manifold 3-port, 20 - R/Rp 3/4 | 3-fach, 20 - R/Rp 3/4 | 474 | DN 15/15/15/20/20

# IfcFlowFitting: REHAU_RAUTITAN_Dummy_Plug_RX+:REHAU_RAUTITAN_Dummy_Plug_RX+ (2)
In: REHAU Starting view
Type - Material: RX
Type - Other - Category: Pipe Fittings; Family Name: REHAU_RAUTITAN_Dummy_Plug_RX+
Type - Constraints - Default Elevation: 0 mm
Type - Identity Data - Type Name: REHAU_RAUTITAN_Dummy_Plug_RX+
Pset_DistributionFlowElementCommon - Reference: REHAU_RAUTITAN_Dummy_Plug_RX+:REHAU_RAUTITAN_Dummy_Plug_RX+; sets with these values: 2
Other - IsCustom: no; Family: REHAU_RAUTITAN_Dummy_Plug_RX+; Family and Type: REHAU_RAUTITAN_Dummy_Plug_RX+: REHAU_RAUTITAN_Dummy_Plug_RX+; Type: REHAU_RAUTITAN_Dummy_Plug_RX+; Type Id: 1089329
Constraints - Elevation from Level: 0 mm; Level: REHAU Starting view
Dimensions - Area: 0.0041524 m2; h: 4.7 mm
Graphics - Use Annotation Scale: no
Identity Data - REH_DESCRIPTION_LANGUAGE: Language : EN; ETIM_CLASS: EC003023; ETIM_MODELLING_CLASS: N/A; REH_BIM_SUPPORT: bim@rehau.com; REH_INFO: 2023.10.10-419114-419114; REH_PRICE_LIST: DE_2023; REH_PRODUCT_PICTURE: https://static.rehau.com/bim/images/1000/jpg/M-275285.jpg
Materials and Finishes - REH_MATERIAL: RX
Mechanical - System Classification: Undefined
Phasing - Phase Created: New Construction
Insulation - Insulation Thickness: 0 mm
Name (REHAU_RAUTITAN_Dummy_Plug_RX+:REHAU_RAUTITAN_Dummy_Plug_RX+:...) | h1 (mm) | h2 (mm) | h3 (mm) | Nominal Diameter 1 (mm) = DN1 (mm) = Maximum Size (mm) = Minimum Size (mm) = REH_DIMENSION | Do1 (mm) | Dr1 (mm) | L1 (mm) | Size = Overall Size | Volume (m3) | Z1 (mm) | PID = REH_SUPPLIER_PID | REH_DESCRIPTION_SHORT | REH_GTIN | REH_NETWEIGHT_G/PC | REH_NOMINAL_DIAMETER
1444926 | 2.86 | 4.95 | 18 | 12 | 16 | 22.5 | 24 | 12 mmø | 0.00000343516 | 8.5 | 14563871001 | REHAU Dummy Plug RAUTITAN RX+ 12 | 4061264398018 | 25 | DN 12
1445034 | 3.61 | 6.25 | 22.5 | 15 | 20 | 26.5 | 28.5 | 15 mmø | 0.00000550055 | 9 | 14563881001 | REHAU Dummy Plug RAUTITAN RX+ 15 | 4061264398025 | 41 | DN 15

# IfcFlowFitting: REHAU_RAUTITAN_Elbow adapter RX+, with external thread:REHAU_RAUTITAN_Elbow adapter RX+, with external thread (8)
In: REHAU Starting view
Type - Material: RX
Type - Other - Category: Pipe Fittings; Family Name: REHAU_RAUTITAN_Elbow adapter RX+, with external thread
Type - Constraints - Default Elevation: 0 mm
Type - Identity Data - ETIM_CLASS: EC003024; ETIM_MODELLING_CLASS: MC000011; Manufacturer: REHAU; REH_BIM_SUPPORT: bim@rehau.com; REH_INFO: 2023.03.10-416508-416508; REH_PRICE_LIST: DE_2022; REH_PRODUCT_PICTURE: https://static.rehau.com/bim/images/1000/jpg/M-52308.jpg; Type Name: REHAU_RAUTITAN_Elbow adapter RX+, with external thread; URL: www.rehau.com
Type - Materials and Finishes - REH_MATERIAL: RX
Type - Pset_ManufacturerTypeInformation - Manufacturer: REHAU
Pset_DistributionFlowElementCommon - Reference: REHAU_RAUTITAN_Elbow adapter RX+, with external thread:REHAU_RAUTITAN_Elbow adapter RX+, with external thread; sets with these values: 2
Other - IsCustom: no; Family: REHAU_RAUTITAN_Elbow adapter RX+, with external thread; Family and Type: REHAU_RAUTITAN_Elbow adapter RX+, with external thread: REHAU_RAUTITAN_Elbow adapter RX+, with external thread; Type: REHAU_RAUTITAN_Elbow adapter RX+, with external thread; Type Id: 1089331
Constraints - Elevation from Level: 0 mm; Level: REHAU Starting view
Dimensions - a: 90 deg; REH_ANGLE_CHECK: 90 deg; Area: 0.0041524 m2
Graphics - Use Annotation Scale: no
Identity Data - REH_DESCRIPTION_LANGUAGE: Language : EN
Mechanical - System Classification: Undefined
Phasing - Phase Created: New Construction
Insulation - Insulation Thickness: 0 mm
Name | Description = REH_DESCRIPTION_SHORT | Nominal Diameter 1 (mm) = DN1 (mm) | Nominal Diameter 2 (mm) = DN2 (mm) | Do1 (mm) | Dr1 (mm) | h (mm) | L1 (mm) | L2 (mm) | Maximum Size (mm) | Minimum Size (mm) | r (mm) | Size = Overall Size | SW2 (mm) | t1 (mm) | Volume (m3) | Z1 (mm) | Z2 (mm) | PID = REH_SUPPLIER_PID | REH_DIMENSION | REH_GTIN | REH_NETWEIGHT_G/PC | REH_NOMINAL_DIAMETER
REHAU_RAUTITAN_Elbow_PX | REHAU Elbow adaptor RAUTITAN RX+ 16 - R 1/2 | 12 | 15 | 16 | 22.5 | 7 | 39.8 | 26 | 15 | 12 | 21.91 | 15 mmø-12 mmø | 22 | 3.8 | 0.0000115621 | 24.3 | 12.8 | 14563471001 | 16 - R 1/2 | 4061264397615 | 78 | DN 12/15
REHAU_RAUTITAN_Elbow_PX | REHAU Elbow adaptor RAUTITAN RX+ 20 - R 1/2 | 15 | 15 | 20 | 26.5 | 7 | 42 | 27.9 | 15 | 15 | 21.91 | 15 mmø-15 mmø | 22 | 4.3 | 0.0000125772 | 22.5 | 14.7 | 14563481001 | 20 - R 1/2 | 4061264397622 | 89 | DN 15/15
REHAU_RAUTITAN_Elbow_PX | REHAU Elbow adaptor RAUTITAN RX+ 20 - R 3/4 | 15 | 20 | 20 | 26.5 | 7 | 44.4 | 28 | 20 | 15 | 26.21 | 20 mmø-15 mmø | 27 | 4.29 | 0.0000172216 | 24.9 | 13.52 | 14563491001 | 20 - R 3/4 | 4061264397639 | 108 | DN 15/20
REHAU_RAUTITAN_Elbow_PX | REHAU Elbow adaptor RAUTITAN RX+ 25 - R 3/4 | 20 | 20 | 25 | 33.59 | 7 | 51.6 | 31.5 | 20 | 20 | 26.21 | 20 mmø-20 mmø | 27 | 4.75 | 0.0000210778 | 24.61 | 17 | 14563501001 | 25 - R 3/4 | 4061264397646 | 142 | DN 20/20
REHAU_RAUTITAN_Elbow_PX | REHAU Elbow adaptor RAUTITAN RX+ 25 - R1 | 20 | 25 | 25 | 33.59 | 8 | 58.38 | 34.8 | 25 | 20 | 33.12 | 25 mmø-20 mmø | 34 | 4.75 | 0.0000335643 | 31.39 | 18 | 14564821001 | 25 - R 1 | 4062178707262 | 181 | DN 20/25
REHAU_RAUTITAN_Elbow_PX | REHAU Elbow adaptor RAUTITAN RX+ 32 - R 3/4 | 25 | 20 | 32 | 40 | 8 | 60 | 34.5 | 25 | 20 | 26 | 25 mmø-20 mmø | 27 | 5.59 | 0.0000262427 | 28 | 20.4 | 14563511001 | 32 - R 3/4 | 4061264397653 | 206 | DN 25/20
REHAU_RAUTITAN_Elbow_PX | REHAU Elbow adaptor RAUTITAN RX+ 32 - R 1 | 25 | 25 | 32 | 40 | 8 | 64.5 | 36.8 | 25 | 25 | 33 | 25 mmø-25 mmø | 34 | 5.5 | 0.0000384334 | 32.5 | 20 | 14563521001 | 32 - R 1 | 4061264397660 | 249 | DN 25/25
REHAU_RAUTITAN_Elbow_PX | REHAU Elbow adaptor RAUTITAN RX+ 40 - R 1 1/4 | 32 | 32 | 40 | 48.98 | 9.58 | 73 | 51.11 | 32 | 32 | 43.88 | 32 mmø-32 mmø | 42 | 9.5 | 0.0000815688 | 41.01 | 32.31 | 14560121001 | 40 - R 1 1/4 | 4064299296359 | 482 | DN 32/32

# IfcFlowFitting: REHAU_RAUTITAN_Elbow adaptor RX+, MeplaFix:REHAU_RAUTITAN_Elbow adaptor RX+, MeplaFix (2)
In: REHAU Starting view
Type - Material: PX, RX
Type - Other - Category: Pipe Fittings; Family Name: REHAU_RAUTITAN_Elbow adaptor RX+, MeplaFix
Type - Constraints - Default Elevation: 0 mm
Type - Identity Data - ETIM_CLASS: EC003024; ETIM_MODELLING_CLASS: N/A; REH_BIM_SUPPORT: bim@rehau.com; REH_INFO: 2024.01.02-419114-419114; REH_PRICE_LIST: DE_2024; REH_PRODUCT_PICTURE: https://static.rehau.com/bim/images/1000/jpg/M-52547.jpg; Type Name: REHAU_RAUTITAN_Elbow adaptor RX+, MeplaFix
Type - Materials and Finishes - REH_MATERIAL: RX
Pset_DistributionFlowElementCommon - Reference: REHAU_RAUTITAN_Elbow adaptor RX+, MeplaFix:REHAU_RAUTITAN_Elbow adaptor RX+, MeplaFix; sets with these values: 2
Other - IsCustom: no; a: 16.35 mm; Family: REHAU_RAUTITAN_Elbow adaptor RX+, MeplaFix; Family and Type: REHAU_RAUTITAN_Elbow adaptor RX+, MeplaFix: REHAU_RAUTITAN_Elbow adaptor RX+, MeplaFix; Type: REHAU_RAUTITAN_Elbow adaptor RX+, MeplaFix; Type Id: 1089333
Constraints - Elevation from Level: 0 mm; Level: REHAU Starting view
Construction - Nominal Diameter 2: 15 mm
Dimensions - Area: 0.0041524 m2; DN2: 15 mm; Dr2: 21.7 mm; Maximum Size: 15 mm; t2: 2.6 mm
Graphics - Use Annotation Scale: no
Identity Data - REH_DESCRIPTION_LANGUAGE: Language : EN
Mechanical - System Classification: Undefined
Phasing - Phase Created: New Construction
Insulation - Insulation Thickness: 0 mm
Name (REHAU_RAUTITAN_Elbow adaptor RX+, MeplaFix:REHAU_RAUTITAN_Elbow adaptor RX+, MeplaFix:...) | b (mm) | c (mm) = r (mm) | Nominal Diameter 1 (mm) = DN1 (mm) = Minimum Size (mm) | Do1 (mm) = Do2 (mm) | Dr1 (mm) | L1 (mm) | L2 (mm) | r1 (mm) | Size = Overall Size | t1 (mm) | Volume (m3) | Z1 (mm) | Z2 (mm) | REH_NETWEIGHT_G/PC | PID = REH_SUPPLIER_PID | REH_DESCRIPTION_SHORT | REH_DIMENSION | REH_GTIN | REH_NOMINAL_DIAMETER
1442400 | 11.5 | 10 | 15 | 20 | 26.5 | 45.05 | 40.6 | 6.65 | 15 mmø-15 mmø | 3.35 | 0.0000246764 | 25.19 | 19.6 | 108 | 14564111001 | REHAU Elbow adaptor RAUTITAN RX+ 20 - MeplaFix | 20 - 15 | 4061264398254 | DN 15/15
1442404 | 10 | 8 | 12 | 16 | 22.5 | 40.55 | 39.1 | 5.13 | 15 mmø-12 mmø | 2.87 | 0.00001852 | 28.05 | 18.1 | 93 | 14564061001 | REHAU Elbow adaptor RAUTITAN RX+ 16 - MeplaFix | 16 - 15 | 4061264398209 | DN 12/15

# IfcFlowFitting: REHAU_RAUTITAN_Pipe bend former sanitary:REHAU_RAUTITAN_Pipe bend former sanitary (8)
In: REHAU Starting view
Type - Material: Steel, Galvanized
Type - Other - Category: Pipe Fittings; Family Name: REHAU_RAUTITAN_Pipe bend former sanitary
Type - Constraints - Default Elevation: 0 mm
Type - Data - ETIM_Colour: Other; ETIM_Model: Single; ETIM_Suitable as floor bend: yes; ETIM_Suitable as wall bend fixture: yes; ETIM_Surface protection: Galvanized; ETIM_With mantle pipe locking: no
Type - Identity Data - ETIM_CLASS: EC011700; ETIM_MODELLING_CLASS: N/A; Manufacturer: REHAU; REH_BIM_SUPPORT: bim@rehau.com; REH_INFO: 2022.12.12-416508-416508; REH_PRICE_LIST: DE_2022; REH_PRODUCT_PICTURE: https://static.rehau.com/bim/images/1000/jpg/M-5632.jpg; Type Name: REHAU_RAUTITAN_Pipe bend former sanitary; URL: www.rehau.com
Type - Materials and Finishes - REH_MATERIAL: Steel, Galvanized
Type - Pset_ManufacturerTypeInformation - Manufacturer: REHAU
Pset_DistributionFlowElementCommon - Reference: REHAU_RAUTITAN_Pipe bend former sanitary:REHAU_RAUTITAN_Pipe bend former sanitary; sets with these values: 2
Other - Family: REHAU_RAUTITAN_Pipe bend former sanitary; Family and Type: REHAU_RAUTITAN_Pipe bend former sanitary: REHAU_RAUTITAN_Pipe bend former sanitary; Type: REHAU_RAUTITAN_Pipe bend former sanitary; Type Id: 1289785
Constraints - Elevation from Level: 0 mm; Level: REHAU Starting view; Moves With Nearby Elements: no
Identity Data - REH_DESCRIPTION_LANGUAGE: Language : EN
Phasing - Phase Created: New Construction
Insulation - Insulation Thickness: 0 mm
Name (REHAU_RAUTITAN_Pipe bend former sanitary:REHAU_RAUTITAN_Pipe bend former sanitary:...) | NominalDiameter = Nominal Diameter (mm) = DN1 (mm) = DN2 (mm) | Angle (deg) = REH_ANGLE_CHECK (deg) | a (mm) | Area (m2) | Do (mm) | r (mm) | r2 (mm) | Volume (m3) | PID = REH_SUPPLIER_PID | REH_DESCRIPTION_SHORT | REH_DIMENSION = REH_NOMINAL_DIAMETER | REH_GTIN | REH_NETWEIGHT_G/PC
1447699 | 12 | 90 | 48 | 0.00567318 | 16 | 48 | 8 | 0.0000077875 | 11388811002 | REHAU Pipe bend former plumbing 16, 90 degree | DN 12/12,90° | 4007360031091 | 55
1447703 | 15 | 90 | 60 | 0.00694655 | 20 | 60 | 10 | 0.00000507054 | 11388911002 | REHAU Pipe bend former plumbing 20, 90 degree | 20, 90° | 4007360031107 | 60
1447707 | 20 | 90 | 75 | 0.0173608 | 25 | 75 | 12.5 | 0.0000667354 | 11383511002 | REHAU Pipe bend former plumbing 25, 90 degree | 25, 90° | 4007360031114 | 150
1447711 | 25 | 90 | 128 | 0.0237782 | 32 | 128 | 16 | 0.0000473487 | 11386411002 | REHAU Pipe bend former plumbing 32, 90 degree | 32, 90° | 4007360031121 | 310
1447715 | 12 | 45 | 20 | 0.00474885 | 16 | 48.2843 | 8 | 0.0000069004 | 11391211002 | REHAU Pipe bend former plumbing 16, 45 degree | 16, 45° | 4007360031138 | 40
1447719 | 15 | 45 | 25 | 0.00552802 | 20 | 60.3553 | 10 | 0.00000369862 | 11391311002 | REHAU Pipe bend former plumbing 20, 45 degree | 20, 45° | 4007360031145 | 45
1447723 | 20 | 45 | 31 | 0.0151568 | 25 | 74.8406 | 12.5 | 0.0000645902 | 11389111002 | REHAU Pipe bend former plumbing 25, 45 degree | 25, 45° | 4007360031152 | 120
1447727 | 25 | 45 | 40 | 0.0175903 | 32 | 96.5685 | 16 | 0.0000412858 | 11389211002 | REHAU Pipe bend former plumbing 32, 45 degree | 32, 45° | 4007360031169 | 210

# IfcFlowFitting: REHAU_RAUTITAN_Pipe bend with former:REHAU_RAUTITAN_Pipe bend with former (8)
In: REHAU Starting view
Type - Material: RAUTITAN flex
Type - Other - Category: Pipe Fittings; Family Name: REHAU_RAUTITAN_Pipe bend with former
Type - Constraints - Default Elevation: 0 mm
Type - Identity Data - Manufacturer: REHAU; REH_BIM_SUPPORT: bim@rehau.com; REH_INFO: 2023.03.13-416508-416508; REH_PRICE_LIST: DE_2022; Type Name: REHAU_RAUTITAN_Pipe bend with former; URL: www.rehau.com
Type - Pset_ManufacturerTypeInformation - Manufacturer: REHAU
Pset_DistributionFlowElementCommon - Reference: REHAU_RAUTITAN_Pipe bend with former:REHAU_RAUTITAN_Pipe bend with former; sets with these values: 2
Other - Family: REHAU_RAUTITAN_Pipe bend with former; Family and Type: REHAU_RAUTITAN_Pipe bend with former: REHAU_RAUTITAN_Pipe bend with former; Type: REHAU_RAUTITAN_Pipe bend with former; Type Id: 1289855
Constraints - Elevation from Level: 0 mm; Level: REHAU Starting view
Graphics - Use Annotation Scale: no
Mechanical - System Classification: Undefined
Phasing - Phase Created: New Construction
Visibility - REH_PIPE_BEND_FORMER: yes
Insulation - Insulation Thickness: 0 mm
Name (REHAU_RAUTITAN_Pipe bend with former:REHAU_RAUTITAN_Pipe bend with former:...) | NominalDiameter = Nominal Diameter (mm) = DN1 (mm) = DN2 (mm) = Maximum Size (mm) = Minimum Size (mm) | Angle (deg) = REH_ANGLE_CHECK (deg) | a (mm) | Do (mm) | ID (mm) | r (mm) | r2 (mm) | Size = Overall Size | Volume (m3) | REH_DIMENSION
1447698 | 12 | 90 | 48 | 16 | 11.6 | 48 | 8 | 12 mmø-12 mmø | 0.0000113876 | DN 12/12,90°
1447702 | 15 | 90 | 60 | 20 | 14.4 | 60 | 10 | 15 mmø-15 mmø | 0.000020916 | 20, 90°
1447706 | 20 | 90 | 75 | 25 | 18 | 75 | 12.5 | 20 mmø-20 mmø | 0.0000481798 | 25, 90°
1447710 | 25 | 90 | 128 | 32 | 23.2 | 128 | 16 | 25 mmø-25 mmø | 0.000109515 | 32, 90°
1447714 | 12 | 45 | 20 | 16 | 11.6 | 48.2843 | 8 | 12 mmø-12 mmø | 0.00000837199 | 16, 45°
1447718 | 15 | 45 | 25 | 20 | 14.4 | 60.3553 | 10 | 15 mmø-15 mmø | 0.0000149364 | 20, 45°
1447722 | 20 | 45 | 31 | 25 | 18 | 74.8406 | 12.5 | 20 mmø-20 mmø | 0.0000363714 | 25, 45°
1447726 | 25 | 45 | 40 | 32 | 23.2 | 96.5685 | 16 | 25 mmø-25 mmø | 0.0000662129 | 32, 45°

# IfcFlowFitting: REHAU_RAUTITAN_T-piece RX+ stabil, outlet with internal thread:REHAU_RAUTITAN_T-piece RX+ stabil, outlet with internal thread (4)
In: REHAU Starting view
Type - Material: RX
Type - Other - Category: Pipe Fittings; Family Name: REHAU_RAUTITAN_T-piece RX+ stabil, outlet with internal thread
Type - Constraints - Default Elevation: 0 mm
Type - Identity Data - ETIM_CLASS: EC003025; ETIM_MODELLING_CLASS: MC000017; REH_BIM_SUPPORT: bim@rehau.com; REH_INFO: 2023.01.19-416508-416508; REH_PRICE_LIST: DE_2023; REH_PRODUCT_PICTURE: https://static.rehau.com/bim/images/1000/jpg/ M-103171.jpg; Type Name: REHAU_RAUTITAN_T-piece RX+ stabil, outlet with internal thread
Type - Materials and Finishes - REH_MATERIAL: RX
Pset_DistributionFlowElementCommon - Reference: REHAU_RAUTITAN_T-piece RX+ stabil, outlet with internal thread:REHAU_RAUTITAN_T-piece RX+ stabil, outlet with internal thread; sets with these values: 2
Other - IsCustom: no; Family: REHAU_RAUTITAN_T-piece RX+ stabil, outlet with internal thread; Family and Type: REHAU_RAUTITAN_T-piece RX+ stabil, outlet with internal thread: REHAU_RAUTITAN_T-piece RX+ stabil, outlet with internal thread; Type: REHAU_RAUTITAN_T-piece RX+ stabil, outlet with internal thread; Type Id: 1089335
Constraints - Elevation from Level: 0 mm; Level: REHAU Starting view
Dimensions - a: 90 deg; REH_ANGLE_CHECK: 90 deg; Area: 0.0041524 m2
Graphics - Use Annotation Scale: no
Identity Data - REH_DESCRIPTION_LANGUAGE: Language : EN
Mechanical - System Classification: Undefined
Phasing - Phase Created: New Construction
Insulation - Insulation Thickness: 0 mm
Name (REHAU_RAUTITAN_T-piece RX+ stabil, outlet with internal thread:REHAU_RAUTITAN_T-piece RX+ stabil, outlet with internal thread:...) | Nominal Diameter 1 (mm) = Nominal Diameter 3 (mm) = DN1 (mm) = DN3 (mm) = Maximum Size (mm) | Nominal Diameter 2 (mm) = DN2 (mm) = Minimum Size (mm) | Do1 (mm) = Do3 (mm) | Dr1 (mm) = Dr2 (mm) = Dr3 (mm) | L1 (mm) = L3 (mm) | L2 (mm) | Size = Overall Size | t1 (mm) = t3 (mm) | Volume (m3) | Z1 (mm) = Z3 (mm) | Z2 (mm) | PID = REH_SUPPLIER_PID | REH_DESCRIPTION_SHORT | REH_DIMENSION | REH_GTIN | REH_NETWEIGHT_G/PC | REH_NOMINAL_DIAMETER
1445066 | 40 | 25 | 50 | 61 | 77 | 40 | 40 mmø-40 mmø-25 mmø | 9 | 0.000129232 | 38 | 27 | 14600251001 | REHAU T-piece RAUTITAN RX+ stabil, 50 - Rp 1 - 50 | 50 - Rp 1 - 50 | 4062178676032 | 910 | DN 40/25/40
1445078 | 50 | 25 | 63 | 74 | 87 | 44 | 50 mmø-50 mmø-25 mmø | 12.5 | 0.000198197 | 41 | 31 | 14600271001 | REHAU T-piece RAUTITAN RX+ stabil, 63 - Rp 1 - 63 | 63 - Rp 1 - 63 | 4062178676049 | 1402 | DN 50/25/50
1447317 | 40 | 15 | 50 | 61 | 69.5 | 36 | 40 mmø-40 mmø-15 mmø | 9 | 0.000107882 | 30.5 | 26 | 14600241001 | REHAU T-piece RAUTITAN RX+ stabil, 50 - Rp 1/2 - 50 | 50 - Rp 1/2 - 50 | 4062178755492 | 802 | DN 40/15/40
1447323 | 50 | 15 | 63 | 74 | 80 | 44 | 50 mmø-50 mmø-15 mmø | 12.5 | 0.000177693 | 34 | 34 | 14600261001 | REHAU T-piece RAUTITAN RX+ stabil, 63 - Rp 1/2 - 63 | 63 - Rp 1/2 - 63 | 4062178755508 | 1284 | DN 50/15/50

# IfcFlowFitting: REHAU_RAUTITAN_T-piece RX+, outlet with internal thread:REHAU_RAUTITAN_T-piece RX+, outlet with internal thread (6)
In: REHAU Starting view
Type - Material: RX
Type - Other - Category: Pipe Fittings; Family Name: REHAU_RAUTITAN_T-piece RX+, outlet with internal thread
Type - Constraints - Default Elevation: 0 mm
Type - Identity Data - ETIM_CLASS: EC003025; ETIM_MODELLING_CLASS: MC000017; Manufacturer: "REHAU"; REH_BIM_SUPPORT: bim@rehau.com; REH_INFO: 2023.01.17-416508-416508; REH_PRICE_LIST: DE_2022; REH_PRODUCT_PICTURE: https://static.rehau.com/bim/images/1000/jpg/M-52497.jpg; Type Name: REHAU_RAUTITAN_T-piece RX+, outlet with internal thread
Type - Materials and Finishes - REH_MATERIAL: RX
Type - Pset_ManufacturerTypeInformation - Manufacturer: "REHAU"
Pset_DistributionFlowElementCommon - Reference: REHAU_RAUTITAN_T-piece RX+, outlet with internal thread:REHAU_RAUTITAN_T-piece RX+, outlet with internal thread; sets with these values: 2
Other - IsCustom: no; Family: REHAU_RAUTITAN_T-piece RX+, outlet with internal thread; Family and Type: REHAU_RAUTITAN_T-piece RX+, outlet with internal thread: REHAU_RAUTITAN_T-piece RX+, outlet with internal thread; Type: REHAU_RAUTITAN_T-piece RX+, outlet with internal thread; Type Id: 1089337
Constraints - Elevation from Level: 0 mm; Level: REHAU Starting view
Dimensions - a: 90 deg; REH_ANGLE_CHECK: 90 deg
Graphics - Use Annotation Scale: no
Identity Data - REH_DESCRIPTION_LANGUAGE: Language : EN
Mechanical - System Classification: Undefined
Phasing - Phase Created: New Construction
Insulation - Insulation Thickness: 0 mm
Name (REHAU_RAUTITAN_T-piece RX+, outlet with internal thread:REHAU_RAUTITAN_T-piece RX+, outlet with internal thread:...) | Nominal Diameter 1 (mm) = DN1 (mm) = Maximum Size (mm) | Nominal Diameter 2 (mm) = DN2 (mm) = Minimum Size (mm) | Nominal Diameter 3 (mm) = DN3 (mm) | Do1 (mm) | Do3 (mm) | Dr1 (mm) | Dr3 (mm) | L1 (mm) | L2 (mm) | L3 (mm) | Size = Overall Size | t1 (mm) | t3 (mm) | Volume (m3) | Z1 (mm) | Z2 (mm) | Z3 (mm) | PID = REH_SUPPLIER_PID | REH_DESCRIPTION_SHORT | REH_DIMENSION | REH_GTIN | REH_NETWEIGHT_G/PC | REH_NOMINAL_DIAMETER
1444940 | 20 | 15 | 20 | 25 | 25 | 33.6 | 33.6 | 51 | 26.16 | 51 | 20 mmø-20 mmø-15 mmø | 4.2 | 4.2 | 0.0000289121 | 24 | 15.15 | 24 | 14564141001 | REHAU T-piece RAUTITAN RX+, 25 - Rp 1/2 - 25 | 25 - Rp 1/2 - 25 | 4061264398285 | 189 | DN 20/15/20
1445084 | 25 | 20 | 20 | 32 | 25 | 39.58 | 33.59 | 60.82 | 29.7 | 55.14 | 25 mmø-20 mmø-20 mmø | 4.95 | 4.2 | 0.0000495085 | 29.16 | 13.7 | 28.14 | 14562981001 | REHAU T-piece RAUTITAN RX+, 32 - Rp 3/4 - 25 | 32 - Rp 3/4 - 25 | 4061264397127 | 277 | DN 25/20/20
1445090 | 25 | 20 | 25 | 32 | 32 | 40 | 40 | 61 | 30 | 61 | 25 mmø-25 mmø-20 mmø | 5 | 5 | 0.0000503671 | 29 | 18 | 29 | 14562971001 | REHAU T-piece RAUTITAN RX+, 32 - Rp 3/4 - 32 | 32 - Rp 3/4 - 32 | 4061264397110 | 327 | DN 25/20/25
1445096 | 32 | 25 | 32 | 40 | 40 | 48.98 | 48.98 | 69 | 34.5 | 69 | 32 mmø-32 mmø-25 mmø | 9 | 9 | 0.000103868 | 37.01 | 20.76 | 37.01 | 14563001001 | REHAU T-piece RAUTITAN RX+, 40 - Rp 1 - 40 | 40 - Rp 1 - 40 | 4061264397141 | 645 | DN 32/25/32
1445102 | 20 | 20 | 20 | 25 | 25 | 33.6 | 33.6 | 55 | 27.06 | 55 | 20 mmø-20 mmø-20 mmø | 4.2 | 4.2 | 0.0000340119 | 28 | 15.08 | 28 | 14562961001 | REHAU T-piece RAUTITAN RX+, 25 - Rp 3/4 - 25 | 25 - Rp 3/4 - 25 | 4061264397103 | 216 | DN 20/20/20
1445108 | 25 | 25 | 25 | 32 | 32 | 40 | 40 | 65 | 33 | 65 | 25 mmø-25 mmø-25 mmø | 5 | 5 | 0.0000626846 | 33 | 18.92 | 33 | 14562991001 | REHAU T-piece RAUTITAN RX+, 32 - Rp 1 - 32 | 32 - Rp 1 - 32 | 4061264397134 | 387 | DN 25/25/25

# IfcFlowFitting: REHAU_RAUTITAN_T-piece_RX+_MeplaFix:REHAU_RAUTITAN_T-piece_RX+_MeplaFix (2)
In: REHAU Starting view
Type - Material: PX, RX
Type - Other - Category: Pipe Fittings; Family Name: REHAU_RAUTITAN_T-piece_RX+_MeplaFix
Type - Constraints - Default Elevation: 0 mm
Type - Identity Data - ETIM_CLASS: EC003025; ETIM_MODELLING_CLASS: N/A; REH_BIM_SUPPORT: bim@rehau.com; REH_INFO: 2023.12.20-419114-419114; REH_PRICE_LIST: DE_2023; REH_PRODUCT_PICTURE: https://static.rehau.com/bim/images/1000/jpg/M-52549.jpg; Type Name: REHAU_RAUTITAN_T-piece_RX+_MeplaFix
Type - Materials and Finishes - REH_MATERIAL: RX
Pset_DistributionFlowElementCommon - Reference: REHAU_RAUTITAN_T-piece_RX+_MeplaFix:REHAU_RAUTITAN_T-piece_RX+_MeplaFix; sets with these values: 2
Other - b: 1.97 mm; d: 12.7 mm; Family: REHAU_RAUTITAN_T-piece_RX+_MeplaFix; Family and Type: REHAU_RAUTITAN_T-piece_RX+_MeplaFix: REHAU_RAUTITAN_T-piece_RX+_MeplaFix; Type: REHAU_RAUTITAN_T-piece_RX+_MeplaFix; Type Id: 1089339
Constraints - Elevation from Level: 0 mm; Level: REHAU Starting view
Construction - Nominal Diameter 2: 13 mm
Dimensions - Area: 0.0041524 m2; DN2: 13 mm; Do2: 13 mm; Dr2: 21.7 mm
Graphics - Use Annotation Scale: no
Identity Data - REH_DESCRIPTION_LANGUAGE: Language : EN
Mechanical - System Classification: Hydronic Supply
Phasing - Phase Created: New Construction
Insulation - Insulation Thickness: 0 mm
Name (REHAU_RAUTITAN_T-piece_RX+_MeplaFix:REHAU_RAUTITAN_T-piece_RX+_MeplaFix:...) | c (mm) | Nominal Diameter 1 (mm) = Nominal Diameter 3 (mm) = DN1 (mm) = DN3 (mm) | Do1 (mm) = Do3 (mm) | Dr1 (mm) = Dr3 (mm) | L1 (mm) = L3 (mm) | L2 (mm) | Maximum Size (mm) | Minimum Size (mm) | Size = Overall Size | t1 (mm) = t3 (mm) | t2 (mm) | Volume (m3) | Z1 (mm) = Z3 (mm) | Z2 (mm) | PID = REH_SUPPLIER_PID | REH_DESCRIPTION_SHORT | REH_DIMENSION | REH_GTIN | REH_NETWEIGHT_G/PC | REH_NOMINAL_DIAMETER
1441482 | 28.1 | 15 | 20 | 26.5 | 45.3 | 40.6 | 15 | 13 | 15 mmø-15 mmø-13 mmø | 4.3 | 2.6 | 0.0000299965 | 25.8 | 19.6 | 14564121001 | REHAU RAUTITAN T-piece RX+ 20 - MeplaFix - 20 | 20 - MeplaFix - 20 | 4061264398261 | 108 | DN 15/MeplaFix/15
1442377 | 26.6 | 12 | 16 | 22.5 | 40.8 | 39.1 | 13 | 12 | 13 mmø-12 mmø-12 mmø | 3.8 | 2.8 | 0.0000253619 | 25.3 | 18.1 | 14564071001 | REHAU RAUTITAN T-piece RX+ 16 - MeplaFix - 16 | 16 - MeplaFix - 16 | 4061264398216 | 93 | DN 12/MeplaFix/12

# IfcFlowFitting: REHAU_RAUTITAN_T-piece_RX+_with external thread:REHAU_RAUTITAN_T-piece_RX+_with external thread (3)
In: REHAU Starting view
Type - Material: RX
Type - Other - Category: Pipe Fittings; Family Name: REHAU_RAUTITAN_T-piece_RX+_with external thread
Type - Constraints - Default Elevation: 0 mm
Type - Identity Data - ETIM_CLASS: EC003025; ETIM_MODELLING_CLASS: MC000017; Manufacturer: REHAU; REH_PRICE_LIST: DE_2022; REH_PRODUCT_PICTURE: https://static.rehau.com/bim/images/1000/jpg/M-52543.jpg; Type Name: REHAU_RAUTITAN_T-piece_RX+_with external thread
Type - Materials and Finishes - REH_MATERIAL: RX
Type - Pset_ManufacturerTypeInformation - Manufacturer: REHAU
Pset_DistributionFlowElementCommon - Reference: REHAU_RAUTITAN_T-piece_RX+_with external thread:REHAU_RAUTITAN_T-piece_RX+_with external thread; sets with these values: 2
Other - Family: REHAU_RAUTITAN_T-piece_RX+_with external thread; Family and Type: REHAU_RAUTITAN_T-piece_RX+_with external thread: REHAU_RAUTITAN_T-piece_RX+_with external thread; Type: REHAU_RAUTITAN_T-piece_RX+_with external thread; Type Id: 1089341
Constraints - Elevation from Level: 0 mm; Level: REHAU Starting view
Dimensions - a: 90 deg; REH_ANGLE_CHECK: 90 deg; Area: 0.0041524 m2; t1: 3.8 mm; t2: 3.8 mm; t3: 7 mm
Graphics - Use Annotation Scale: no
Identity Data - REH_DESCRIPTION_LANGUAGE: Language : EN; REH_INFO: 2022.12.13-416508-416508
Mechanical - System Classification: Undefined
Phasing - Phase Created: New Construction
Insulation - Insulation Thickness: 0 mm
Name (REHAU_RAUTITAN_T-piece_RX+_with external thread:REHAU_RAUTITAN_T-piece_RX+_with external thread:...) | Nominal Diameter 1 (mm) = Nominal Diameter 2 (mm) = DN1 (mm) = DN2 (mm) = Minimum Size (mm) | Nominal Diameter 3 (mm) = DN3 (mm) = Maximum Size (mm) | Do1 (mm) = Do2 (mm) | Dr1 (mm) = Dr2 (mm) | L1 (mm) | L2 (mm) | L3 (mm) | Size = Overall Size | SW3 (mm) | Volume (m3) | Z1 (mm) | Z2 (mm) | Z3 (mm) | REH_NETWEIGHT_G/PC | PID = REH_SUPPLIER_PID | REH_DESCRIPTION_SHORT | REH_DIMENSION | REH_GTIN | REH_NOMINAL_DIAMETER
1444946 | 15 | 20 | 20 | 26.5 | 44.65 | 44.8 | 44.65 | 20 mmø-15 mmø-15 mmø | 27 | 0.0000214264 | 25.15 | 25.3 | 30.15 | 188 | 14564021001 | REHAU T-piece RAUTITAN RX+ 20 - 20 - R 3/4 | 20 - 20 - R 3/4 | 4061264398162 | DN 15/15/15
1445114 | 15 | 15 | 20 | 26.5 | 44.8 | 44.8 | 43.2 | 15 mmø-15 mmø-15 mmø | 22 | 0.0000195785 | 25.3 | 25.3 | 30 | 171 | 14564011001 | REHAU T-piece RAUTITAN RX+ 20 - 20 - R 1/2 | 20 - 20 - R 1/2 | 4061264398155 | DN 15/15/15
1445120 | 12 | 15 | 16 | 22.5 | 40.28 | 40 | 40.24 | 15 mmø-12 mmø-12 mmø | 22 | 0.0000152283 | 24.78 | 24.5 | 27 | 135 | 14564001001 | REHAU T-piece RAUTITAN RX+ 16 - 16 - R 1/2 | 16 - 16 - R 1/2 | 4061264398148 | DN 12/12/15

# IfcFlowFitting: REHAU_RAUTITAN_Wall-T-piece RX+, outlet with internal thread:REHAU_RAUTITAN_Wall-T-piece RX+, outlet with internal thread (3)
In: REHAU Starting view
Type - Material: RX
Type - Other - Category: Pipe Fittings; Family Name: REHAU_RAUTITAN_Wall-T-piece RX+, outlet with internal thread
Type - Constraints - Default Elevation: 0 mm
Type - Identity Data - ETIM_CLASS: EC003025; ETIM_MODELLING_CLASS: MC000017; Manufacturer: REHAU; REH_INFO: 2022.07.04-416508-416508; REH_PRICE_LIST: DE_2022; REH_PRODUCT_PICTURE: https://static.rehau.com/bim/images/1000/jpg/M-53783.jpg; Type Name: REHAU_RAUTITAN_Wall-T-piece RX+, outlet with internal thread
Type - Materials and Finishes - REH_MATERIAL: RX
Type - Pset_ManufacturerTypeInformation - Manufacturer: REHAU
Pset_DistributionFlowElementCommon - Reference: REHAU_RAUTITAN_Wall-T-piece RX+, outlet with internal thread:REHAU_RAUTITAN_Wall-T-piece RX+, outlet with internal thread; sets with these values: 2
Other - IsCustom: no; Family: REHAU_RAUTITAN_Wall-T-piece RX+, outlet with internal thread; Family and Type: REHAU_RAUTITAN_Wall-T-piece RX+, outlet with internal thread: REHAU_RAUTITAN_Wall-T-piece RX+, outlet with internal thread; Type: REHAU_RAUTITAN_Wall-T-piece RX+, outlet with internal thread; Type Id: 1089343
Constraints - Elevation from Level: 0 mm; Level: REHAU Starting view
Construction - Nominal Diameter 2: 15 mm
Dimensions - a: 90 deg; REH_ANGLE_CHECK: 90 deg; Area: 0.0041524 m2; DN2: 15 mm; Maximum Size: 15 mm
Graphics - Use Annotation Scale: no
Identity Data - REH_DESCRIPTION_LANGUAGE: Language : EN
Mechanical - System Classification: Undefined
Phasing - Phase Created: New Construction
Insulation - Insulation Thickness: 0 mm
Name (REHAU_RAUTITAN_Wall-T-piece RX+, outlet with internal thread:REHAU_RAUTITAN_Wall-T-piece RX+, outlet with internal thread:...) | Nominal Diameter 1 (mm) = DN1 (mm) | Nominal Diameter 3 (mm) = DN3 (mm) = Minimum Size (mm) | Do1 (mm) | Do3 (mm) | Dr1 (mm) | Dr3 (mm) | L1 (mm) | L2 (mm) | L3 (mm) | Size = Overall Size | t1 (mm) = t3 (mm) | Volume (m3) | Z1 (mm) | Z2 (mm) | Z3 (mm) | PID = REH_SUPPLIER_PID | REH_DESCRIPTION_SHORT | REH_DIMENSION | REH_GTIN | REH_NETWEIGHT_G/PC | REH_NOMINAL_DIAMETER
1444952 | 12 | 12 | 16 | 16 | 22.5 | 22.5 | 46.65 | 25.8 | 46.65 | 15 mmø-12 mmø-12 mmø | 3.3 | 0.0000185907 | 31.15 | 14.86 | 31.15 | 14562911001 | REHAU Wall-mounted T-piece RAUTITAN RX+, 16 - Rp 1/2 - 16 | DN 12/15/12 | 4061264397059 | 154 | 16 / Rp 1/2 / 16
1445126 | 15 | 12 | 20 | 16 | 22.68 | 26.68 | 46.82 | 23.75 | 51.31 | 15 mmø-15 mmø-12 mmø | 3.8 | 0.0000223546 | 31.32 | 9.5 | 31.81 | 14562931001 | REHAU Wall-mounted T-piece RAUTITAN RX+, 20 - Rp 1/2 - 16 | DN 15/15/12 | 4061264397073 | 180 | 20 / Rp 1/2 / 16
1445132 | 15 | 15 | 20 | 20 | 26.5 | 26.5 | 49.65 | 23.75 | 49.65 | 15 mmø-15 mmø-15 mmø | 3.8 | 0.0000215793 | 30.15 | 12.94 | 30.15 | 14562941001 | REHAU Wall-mounted T-piece RAUTITAN RX+, 20 - Rp 1/2 - 20 | DN 15/15/15 | 4061264397080 | 177 | 20 / Rp 1/2 / 20

# IfcFlowFitting: Sleeve:LX 7,4 (197)
In: REHAU Starting view
Type - Material: Br
Type - Other - Category: Pipe Fittings; Family Name: Sleeve
Type - Constraints - Default Elevation: 0 mm
Type - Identity Data - Cost: 0; Description: LX 7,4; Manufacturer: REHAU; Model: LX 7,4; REHAU Info: 14.02.2024-420668-420668; Type Name: LX 7,4
Type - Materials and Finishes - Mat. Sleeve: Br
Type - Pset_ManufacturerTypeInformation - Manufacturer: REHAU
Pset_DistributionFlowElementCommon - Reference: Sleeve:LX 7,4; sets with these values: 2
Other - IsCustom: no; Family: Sleeve; Family and Type: Sleeve: LX 7,4; Type: LX 7,4; Type Id: 986514; T1: Sleeve DN
Constraints - Elevation from Level: 0 mm; Level: REHAU Starting view; Moves With Nearby Elements: no
Data - Language: Description en; Language Tender Text: Tender Text en; PID Check: 1 mm; Region Check: Check DE; Region PID: PID DE; Region URL: Product URL DE
Dimensions - Area: 0.00262625 m2
Identity Data - Sorting: 0; ETIM Class: EC011668; ETIM Group: EG015540; ETIM Name: Accessories/spare parts for fittings; Tender text: -
Phasing - Phase Created: New Construction
Insulation - Insulation Thickness: 0 mm
Name (Sleeve:LX 7,4:...) | DN1 (mm) | L1 (mm) | Volume (m3) | Description long | GTIN | PID | Product Group | Product URL | Weight
986611 | 15 | 25 | 0.00000393937 | REHAU Compression sleeve RAUT. MX/LX 20 | 4007360031060 | 12596151002 | 1959 | https://oxomi.com/p/3000126/datasheet/-/12596151002 | 0.028
986613 | 15 | 25 | 0.00000393937 | REHAU Compression sleeve RAUT. MX/LX 20 | 4007360031060 | 12596151002 | 1959 | https://oxomi.com/p/3000126/datasheet/-/12596151002 | 0.028
986618 | 20 | 29 | 0.0000058041 | REHAU Compression sleeve RAUT. MX/LX +G 25 | 4007360377519 | 12596251402 | 1960 | https://oxomi.com/p/3000126/datasheet/-/12596251402 | 0.046
986620 | 20 | 29 | 0.0000058041 | REHAU Compression sleeve RAUT. MX/LX +G 25 | 4007360377519 | 12596251402 | 1960 | https://oxomi.com/p/3000126/datasheet/-/12596251402 | 0.046
986624 | 25 | 34 | 0.0000131097 | REHAU Compression sleeve RAUT. MX/LX 32 | 4007360168698 | 11371661001 | 1961 | https://oxomi.com/p/3000126/datasheet/-/11371661001 | 0.096
986626 | 25 | 34 | 0.0000131097 | REHAU Compression sleeve RAUT. MX/LX 32 | 4007360168698 | 11371661001 | 1961 | https://oxomi.com/p/3000126/datasheet/-/11371661001 | 0.096
986630 | 32 | 37 | 0.0000199643 | REHAU Compression sleeve RAUT. MX/LX 40 | 4007360186487 | 11372961001 | 1962 | https://oxomi.com/p/3000126/datasheet/-/11372961001 | 0.162
986632 | 32 | 37 | 0.0000199643 | REHAU Compression sleeve RAUT. MX/LX 40 | 4007360186487 | 11372961001 | 1962 | https://oxomi.com/p/3000126/datasheet/-/11372961001 | 0.162
986636 | 40 | 44 | 0.0000372872 | REHAU Compression sleeve RAUTITAN MX/LX 50 | 4007360031817 | 11397711002 | 1963 | https://oxomi.com/p/3000126/datasheet/-/11397711002 | 0.293
986638 | 40 | 44 | 0.0000372872 | REHAU Compression sleeve RAUTITAN MX/LX 50 | 4007360031817 | 11397711002 | 1963 | https://oxomi.com/p/3000126/datasheet/-/11397711002 | 0.293
986642 | 50 | 53 | 0.0000553035 | REHAU Compression sleeve RAUTITAN MX/LX 63 | 4007360031824 | 11397811002 | 1964 | https://oxomi.com/p/3000126/datasheet/-/11397811002 | 0.439
986644 | 50 | 53 | 0.0000553035 | REHAU Compression sleeve RAUTITAN MX/LX 63 | 4007360031824 | 11397811002 | 1964 | https://oxomi.com/p/3000126/datasheet/-/11397811002 | 0.439
986648 | 50 | 53 | 0.0000553035 | REHAU Compression sleeve RAUTITAN MX/LX 63 | 4007360031824 | 11397811002 | 1964 | https://oxomi.com/p/3000126/datasheet/-/11397811002 | 0.439
986650 | 50 | 53 | 0.0000553035 | REHAU Compression sleeve RAUTITAN MX/LX 63 | 4007360031824 | 11397811002 | 1964 | https://oxomi.com/p/3000126/datasheet/-/11397811002 | 0.439
986652 | 40 | 44 | 0.0000372872 | REHAU Compression sleeve RAUTITAN MX/LX 50 | 4007360031817 | 11397711002 | 1963 | https://oxomi.com/p/3000126/datasheet/-/11397711002 | 0.293
986654 | 40 | 44 | 0.0000372872 | REHAU Compression sleeve RAUTITAN MX/LX 50 | 4007360031817 | 11397711002 | 1963 | https://oxomi.com/p/3000126/datasheet/-/11397711002 | 0.293
986857 | 40 | 44 | 0.0000372872 | REHAU Compression sleeve RAUTITAN MX/LX 50 | 4007360031817 | 11397711002 | 1963 | https://oxomi.com/p/3000126/datasheet/-/11397711002 | 0.293
986859 | 40 | 44 | 0.0000372872 | REHAU Compression sleeve RAUTITAN MX/LX 50 | 4007360031817 | 11397711002 | 1963 | https://oxomi.com/p/3000126/datasheet/-/11397711002 | 0.293
986870 | 50 | 53 | 0.0000553035 | REHAU Compression sleeve RAUTITAN MX/LX 63 | 4007360031824 | 11397811002 | 1964 | https://oxomi.com/p/3000126/datasheet/-/11397811002 | 0.439
986872 | 50 | 53 | 0.0000553035 | REHAU Compression sleeve RAUTITAN MX/LX 63 | 4007360031824 | 11397811002 | 1964 | https://oxomi.com/p/3000126/datasheet/-/11397811002 | 0.439
986996 | 50 | 53 | 0.0000553035 | REHAU Compression sleeve RAUTITAN MX/LX 63 | 4007360031824 | 11397811002 | 1964 | https://oxomi.com/p/3000126/datasheet/-/11397811002 | 0.439
986998 | 50 | 53 | 0.0000553035 | REHAU Compression sleeve RAUTITAN MX/LX 63 | 4007360031824 | 11397811002 | 1964 | https://oxomi.com/p/3000126/datasheet/-/11397811002 | 0.439
987000 | 40 | 44 | 0.0000372872 | REHAU Compression sleeve RAUTITAN MX/LX 50 | 4007360031817 | 11397711002 | 1963 | https://oxomi.com/p/3000126/datasheet/-/11397711002 | 0.293
987002 | 40 | 44 | 0.0000372872 | REHAU Compression sleeve RAUTITAN MX/LX 50 | 4007360031817 | 11397711002 | 1963 | https://oxomi.com/p/3000126/datasheet/-/11397711002 | 0.293
1005944 | 20 | 29 | 0.0000058041 | REHAU Compression sleeve RAUT. MX/LX +G 25 | 4007360377519 | 12596251402 | 1960 | https://oxomi.com/p/3000126/datasheet/-/12596251402 | 0.046
1005946 | 20 | 29 | 0.0000058041 | REHAU Compression sleeve RAUT. MX/LX +G 25 | 4007360377519 | 12596251402 | 1960 | https://oxomi.com/p/3000126/datasheet/-/12596251402 | 0.046
1005948 | 20 | 29 | 0.0000058041 | REHAU Compression sleeve RAUT. MX/LX +G 25 | 4007360377519 | 12596251402 | 1960 | https://oxomi.com/p/3000126/datasheet/-/12596251402 | 0.046
1005951 | 25 | 34 | 0.0000131097 | REHAU Compression sleeve RAUT. MX/LX 32 | 4007360168698 | 11371661001 | 1961 | https://oxomi.com/p/3000126/datasheet/-/11371661001 | 0.096
1005953 | 25 | 34 | 0.0000131097 | REHAU Compression sleeve RAUT. MX/LX 32 | 4007360168698 | 11371661001 | 1961 | https://oxomi.com/p/3000126/datasheet/-/11371661001 | 0.096
1005955 | 25 | 34 | 0.0000131097 | REHAU Compression sleeve RAUT. MX/LX 32 | 4007360168698 | 11371661001 | 1961 | https://oxomi.com/p/3000126/datasheet/-/11371661001 | 0.096
1005958 | 32 | 37 | 0.0000199643 | REHAU Compression sleeve RAUT. MX/LX 40 | 4007360186487 | 11372961001 | 1962 | https://oxomi.com/p/3000126/datasheet/-/11372961001 | 0.162
1005960 | 32 | 37 | 0.0000199643 | REHAU Compression sleeve RAUT. MX/LX 40 | 4007360186487 | 11372961001 | 1962 | https://oxomi.com/p/3000126/datasheet/-/11372961001 | 0.162
1005962 | 32 | 37 | 0.0000199643 | REHAU Compression sleeve RAUT. MX/LX 40 | 4007360186487 | 11372961001 | 1962 | https://oxomi.com/p/3000126/datasheet/-/11372961001 | 0.162
1005966 | 40 | 44 | 0.0000372872 | REHAU Compression sleeve RAUTITAN MX/LX 50 | 4007360031817 | 11397711002 | 1963 | https://oxomi.com/p/3000126/datasheet/-/11397711002 | 0.293
1005968 | 40 | 44 | 0.0000372872 | REHAU Compression sleeve RAUTITAN MX/LX 50 | 4007360031817 | 11397711002 | 1963 | https://oxomi.com/p/3000126/datasheet/-/11397711002 | 0.293
1005970 | 40 | 44 | 0.0000372872 | REHAU Compression sleeve RAUTITAN MX/LX 50 | 4007360031817 | 11397711002 | 1963 | https://oxomi.com/p/3000126/datasheet/-/11397711002 | 0.293
1005974 | 50 | 53 | 0.0000553035 | REHAU Compression sleeve RAUTITAN MX/LX 63 | 4007360031824 | 11397811002 | 1964 | https://oxomi.com/p/3000126/datasheet/-/11397811002 | 0.439
1005976 | 50 | 53 | 0.0000553035 | REHAU Compression sleeve RAUTITAN MX/LX 63 | 4007360031824 | 11397811002 | 1964 | https://oxomi.com/p/3000126/datasheet/-/11397811002 | 0.439
1005978 | 50 | 53 | 0.0000553035 | REHAU Compression sleeve RAUTITAN MX/LX 63 | 4007360031824 | 11397811002 | 1964 | https://oxomi.com/p/3000126/datasheet/-/11397811002 | 0.439
1005982 | 15 | 25 | 0.00000393937 | REHAU Compression sleeve RAUT. MX/LX 20 | 4007360031060 | 12596151002 | 1959 | https://oxomi.com/p/3000126/datasheet/-/12596151002 | 0.028
1005984 | 15 | 25 | 0.00000393937 | REHAU Compression sleeve RAUT. MX/LX 20 | 4007360031060 | 12596151002 | 1959 | https://oxomi.com/p/3000126/datasheet/-/12596151002 | 0.028
1005986 | 15 | 25 | 0.00000393937 | REHAU Compression sleeve RAUT. MX/LX 20 | 4007360031060 | 12596151002 | 1959 | https://oxomi.com/p/3000126/datasheet/-/12596151002 | 0.028
1006000 | 20 | 29 | 0.0000058041 | REHAU Compression sleeve RAUT. MX/LX +G 25 | 4007360377519 | 12596251402 | 1960 | https://oxomi.com/p/3000126/datasheet/-/12596251402 | 0.046
1006002 | 15 | 25 | 0.00000393937 | REHAU Compression sleeve RAUT. MX/LX 20 | 4007360031060 | 12596151002 | 1959 | https://oxomi.com/p/3000126/datasheet/-/12596151002 | 0.028
1006004 | 20 | 29 | 0.0000058041 | REHAU Compression sleeve RAUT. MX/LX +G 25 | 4007360377519 | 12596251402 | 1960 | https://oxomi.com/p/3000126/datasheet/-/12596251402 | 0.046
1006008 | 25 | 34 | 0.0000131097 | REHAU Compression sleeve RAUT. MX/LX 32 | 4007360168698 | 11371661001 | 1961 | https://oxomi.com/p/3000126/datasheet/-/11371661001 | 0.096
1006010 | 20 | 29 | 0.0000058041 | REHAU Compression sleeve RAUT. MX/LX +G 25 | 4007360377519 | 12596251402 | 1960 | https://oxomi.com/p/3000126/datasheet/-/12596251402 | 0.046
1006012 | 25 | 34 | 0.0000131097 | REHAU Compression sleeve RAUT. MX/LX 32 | 4007360168698 | 11371661001 | 1961 | https://oxomi.com/p/3000126/datasheet/-/11371661001 | 0.096
1006015 | 32 | 37 | 0.0000199643 | REHAU Compression sleeve RAUT. MX/LX 40 | 4007360186487 | 11372961001 | 1962 | https://oxomi.com/p/3000126/datasheet/-/11372961001 | 0.162
1006017 | 25 | 34 | 0.0000131097 | REHAU Compression sleeve RAUT. MX/LX 32 | 4007360168698 | 11371661001 | 1961 | https://oxomi.com/p/3000126/datasheet/-/11371661001 | 0.096
1006019 | 32 | 37 | 0.0000199643 | REHAU Compression sleeve RAUT. MX/LX 40 | 4007360186487 | 11372961001 | 1962 | https://oxomi.com/p/3000126/datasheet/-/11372961001 | 0.162
1006023 | 40 | 44 | 0.0000372872 | REHAU Compression sleeve RAUTITAN MX/LX 50 | 4007360031817 | 11397711002 | 1963 | https://oxomi.com/p/3000126/datasheet/-/11397711002 | 0.293
1006025 | 32 | 37 | 0.0000199643 | REHAU Compression sleeve RAUT. MX/LX 40 | 4007360186487 | 11372961001 | 1962 | https://oxomi.com/p/3000126/datasheet/-/11372961001 | 0.162
1006027 | 40 | 44 | 0.0000372872 | REHAU Compression sleeve RAUTITAN MX/LX 50 | 4007360031817 | 11397711002 | 1963 | https://oxomi.com/p/3000126/datasheet/-/11397711002 | 0.293
1006032 | 50 | 53 | 0.0000553035 | REHAU Compression sleeve RAUTITAN MX/LX 63 | 4007360031824 | 11397811002 | 1964 | https://oxomi.com/p/3000126/datasheet/-/11397811002 | 0.439
1006034 | 40 | 44 | 0.0000372872 | REHAU Compression sleeve RAUTITAN MX/LX 50 | 4007360031817 | 11397711002 | 1963 | https://oxomi.com/p/3000126/datasheet/-/11397711002 | 0.293
1006036 | 50 | 53 | 0.0000553035 | REHAU Compression sleeve RAUTITAN MX/LX 63 | 4007360031824 | 11397811002 | 1964 | https://oxomi.com/p/3000126/datasheet/-/11397811002 | 0.439
1006041 | 15 | 25 | 0.00000393937 | REHAU Compression sleeve RAUT. MX/LX 20 | 4007360031060 | 12596151002 | 1959 | https://oxomi.com/p/3000126/datasheet/-/12596151002 | 0.028
1006045 | 15 | 25 | 0.00000393937 | REHAU Compression sleeve RAUT. MX/LX 20 | 4007360031060 | 12596151002 | 1959 | https://oxomi.com/p/3000126/datasheet/-/12596151002 | 0.028
1006050 | 20 | 29 | 0.0000058041 | REHAU Compression sleeve RAUT. MX/LX +G 25 | 4007360377519 | 12596251402 | 1960 | https://oxomi.com/p/3000126/datasheet/-/12596251402 | 0.046
1006054 | 20 | 29 | 0.0000058041 | REHAU Compression sleeve RAUT. MX/LX +G 25 | 4007360377519 | 12596251402 | 1960 | https://oxomi.com/p/3000126/datasheet/-/12596251402 | 0.046
1006058 | 25 | 34 | 0.0000131097 | REHAU Compression sleeve RAUT. MX/LX 32 | 4007360168698 | 11371661001 | 1961 | https://oxomi.com/p/3000126/datasheet/-/11371661001 | 0.096
1006060 | 15 | 25 | 0.00000393937 | REHAU Compression sleeve RAUT. MX/LX 20 | 4007360031060 | 12596151002 | 1959 | https://oxomi.com/p/3000126/datasheet/-/12596151002 | 0.028
1006062 | 25 | 34 | 0.0000131097 | REHAU Compression sleeve RAUT. MX/LX 32 | 4007360168698 | 11371661001 | 1961 | https://oxomi.com/p/3000126/datasheet/-/11371661001 | 0.096
1006066 | 32 | 37 | 0.0000199643 | REHAU Compression sleeve RAUT. MX/LX 40 | 4007360186487 | 11372961001 | 1962 | https://oxomi.com/p/3000126/datasheet/-/11372961001 | 0.162
1006068 | 20 | 29 | 0.0000058041 | REHAU Compression sleeve RAUT. MX/LX +G 25 | 4007360377519 | 12596251402 | 1960 | https://oxomi.com/p/3000126/datasheet/-/12596251402 | 0.046
1006070 | 32 | 37 | 0.0000199643 | REHAU Compression sleeve RAUT. MX/LX 40 | 4007360186487 | 11372961001 | 1962 | https://oxomi.com/p/3000126/datasheet/-/11372961001 | 0.162
1006074 | 40 | 44 | 0.0000372872 | REHAU Compression sleeve RAUTITAN MX/LX 50 | 4007360031817 | 11397711002 | 1963 | https://oxomi.com/p/3000126/datasheet/-/11397711002 | 0.293
1006076 | 25 | 34 | 0.0000131097 | REHAU Compression sleeve RAUT. MX/LX 32 | 4007360168698 | 11371661001 | 1961 | https://oxomi.com/p/3000126/datasheet/-/11371661001 | 0.096
1006078 | 40 | 44 | 0.0000372872 | REHAU Compression sleeve RAUTITAN MX/LX 50 | 4007360031817 | 11397711002 | 1963 | https://oxomi.com/p/3000126/datasheet/-/11397711002 | 0.293
1006082 | 50 | 53 | 0.0000553035 | REHAU Compression sleeve RAUTITAN MX/LX 63 | 4007360031824 | 11397811002 | 1964 | https://oxomi.com/p/3000126/datasheet/-/11397811002 | 0.439
1006084 | 25 | 34 | 0.0000131097 | REHAU Compression sleeve RAUT. MX/LX 32 | 4007360168698 | 11371661001 | 1961 | https://oxomi.com/p/3000126/datasheet/-/11371661001 | 0.096
1006086 | 50 | 53 | 0.0000553035 | REHAU Compression sleeve RAUTITAN MX/LX 63 | 4007360031824 | 11397811002 | 1964 | https://oxomi.com/p/3000126/datasheet/-/11397811002 | 0.439
1006091 | 15 | 25 | 0.00000393937 | REHAU Compression sleeve RAUT. MX/LX 20 | 4007360031060 | 12596151002 | 1959 | https://oxomi.com/p/3000126/datasheet/-/12596151002 | 0.028
1006095 | 15 | 25 | 0.00000393937 | REHAU Compression sleeve RAUT. MX/LX 20 | 4007360031060 | 12596151002 | 1959 | https://oxomi.com/p/3000126/datasheet/-/12596151002 | 0.028
1006100 | 40 | 44 | 0.0000372872 | REHAU Compression sleeve RAUTITAN MX/LX 50 | 4007360031817 | 11397711002 | 1963 | https://oxomi.com/p/3000126/datasheet/-/11397711002 | 0.293
1006102 | 20 | 29 | 0.0000058041 | REHAU Compression sleeve RAUT. MX/LX +G 25 | 4007360377519 | 12596251402 | 1960 | https://oxomi.com/p/3000126/datasheet/-/12596251402 | 0.046
1006104 | 40 | 44 | 0.0000372872 | REHAU Compression sleeve RAUTITAN MX/LX 50 | 4007360031817 | 11397711002 | 1963 | https://oxomi.com/p/3000126/datasheet/-/11397711002 | 0.293
1006111 | 15 | 25 | 0.00000393937 | REHAU Compression sleeve RAUT. MX/LX 20 | 4007360031060 | 12596151002 | 1959 | https://oxomi.com/p/3000126/datasheet/-/12596151002 | 0.028
1006118 | 15 | 25 | 0.00000393937 | REHAU Compression sleeve RAUT. MX/LX 20 | 4007360031060 | 12596151002 | 1959 | https://oxomi.com/p/3000126/datasheet/-/12596151002 | 0.028
1006120 | 20 | 29 | 0.0000058041 | REHAU Compression sleeve RAUT. MX/LX +G 25 | 4007360377519 | 12596251402 | 1960 | https://oxomi.com/p/3000126/datasheet/-/12596251402 | 0.046
1006122 | 15 | 25 | 0.00000393937 | REHAU Compression sleeve RAUT. MX/LX 20 | 4007360031060 | 12596151002 | 1959 | https://oxomi.com/p/3000126/datasheet/-/12596151002 | 0.028
1006136 | 20 | 29 | 0.0000058041 | REHAU Compression sleeve RAUT. MX/LX +G 25 | 4007360377519 | 12596251402 | 1960 | https://oxomi.com/p/3000126/datasheet/-/12596251402 | 0.046
1006138 | 15 | 25 | 0.00000393937 | REHAU Compression sleeve RAUT. MX/LX 20 | 4007360031060 | 12596151002 | 1959 | https://oxomi.com/p/3000126/datasheet/-/12596151002 | 0.028
1006140 | 15 | 25 | 0.00000393937 | REHAU Compression sleeve RAUT. MX/LX 20 | 4007360031060 | 12596151002 | 1959 | https://oxomi.com/p/3000126/datasheet/-/12596151002 | 0.028
1006144 | 25 | 34 | 0.0000131097 | REHAU Compression sleeve RAUT. MX/LX 32 | 4007360168698 | 11371661001 | 1961 | https://oxomi.com/p/3000126/datasheet/-/11371661001 | 0.096
1006146 | 20 | 29 | 0.0000058041 | REHAU Compression sleeve RAUT. MX/LX +G 25 | 4007360377519 | 12596251402 | 1960 | https://oxomi.com/p/3000126/datasheet/-/12596251402 | 0.046
1006148 | 20 | 29 | 0.0000058041 | REHAU Compression sleeve RAUT. MX/LX +G 25 | 4007360377519 | 12596251402 | 1960 | https://oxomi.com/p/3000126/datasheet/-/12596251402 | 0.046
1006150 | 32 | 37 | 0.0000199643 | REHAU Compression sleeve RAUT. MX/LX 40 | 4007360186487 | 11372961001 | 1962 | https://oxomi.com/p/3000126/datasheet/-/11372961001 | 0.162
1006152 | 25 | 34 | 0.0000131097 | REHAU Compression sleeve RAUT. MX/LX 32 | 4007360168698 | 11371661001 | 1961 | https://oxomi.com/p/3000126/datasheet/-/11371661001 | 0.096
1006154 | 25 | 34 | 0.0000131097 | REHAU Compression sleeve RAUT. MX/LX 32 | 4007360168698 | 11371661001 | 1961 | https://oxomi.com/p/3000126/datasheet/-/11371661001 | 0.096
1006159 | 15 | 25 | 0.00000393937 | REHAU Compression sleeve RAUT. MX/LX 20 | 4007360031060 | 12596151002 | 1959 | https://oxomi.com/p/3000126/datasheet/-/12596151002 | 0.028
1006177 | 20 | 29 | 0.0000058041 | REHAU Compression sleeve RAUT. MX/LX +G 25 | 4007360377519 | 12596251402 | 1960 | https://oxomi.com/p/3000126/datasheet/-/12596251402 | 0.046
1006179 | 20 | 29 | 0.0000058041 | REHAU Compression sleeve RAUT. MX/LX +G 25 | 4007360377519 | 12596251402 | 1960 | https://oxomi.com/p/3000126/datasheet/-/12596251402 | 0.046
1006181 | 15 | 25 | 0.00000393937 | REHAU Compression sleeve RAUT. MX/LX 20 | 4007360031060 | 12596151002 | 1959 | https://oxomi.com/p/3000126/datasheet/-/12596151002 | 0.028
1006185 | 25 | 34 | 0.0000131097 | REHAU Compression sleeve RAUT. MX/LX 32 | 4007360168698 | 11371661001 | 1961 | https://oxomi.com/p/3000126/datasheet/-/11371661001 | 0.096
1006187 | 25 | 34 | 0.0000131097 | REHAU Compression sleeve RAUT. MX/LX 32 | 4007360168698 | 11371661001 | 1961 | https://oxomi.com/p/3000126/datasheet/-/11371661001 | 0.096
1006189 | 20 | 29 | 0.0000058041 | REHAU Compression sleeve RAUT. MX/LX +G 25 | 4007360377519 | 12596251402 | 1960 | https://oxomi.com/p/3000126/datasheet/-/12596251402 | 0.046
1006194 | 15 | 25 | 0.00000393937 | REHAU Compression sleeve RAUT. MX/LX 20 | 4007360031060 | 12596151002 | 1959 | https://oxomi.com/p/3000126/datasheet/-/12596151002 | 0.028
1006196 | 15 | 25 | 0.00000393937 | REHAU Compression sleeve RAUT. MX/LX 20 | 4007360031060 | 12596151002 | 1959 | https://oxomi.com/p/3000126/datasheet/-/12596151002 | 0.028
1006202 | 40 | 44 | 0.0000372872 | REHAU Compression sleeve RAUTITAN MX/LX 50 | 4007360031817 | 11397711002 | 1963 | https://oxomi.com/p/3000126/datasheet/-/11397711002 | 0.293
1006204 | 25 | 34 | 0.0000131097 | REHAU Compression sleeve RAUT. MX/LX 32 | 4007360168698 | 11371661001 | 1961 | https://oxomi.com/p/3000126/datasheet/-/11371661001 | 0.096
1006206 | 32 | 37 | 0.0000199643 | REHAU Compression sleeve RAUT. MX/LX 40 | 4007360186487 | 11372961001 | 1962 | https://oxomi.com/p/3000126/datasheet/-/11372961001 | 0.162
1006211 | 20 | 29 | 0.0000058041 | REHAU Compression sleeve RAUT. MX/LX +G 25 | 4007360377519 | 12596251402 | 1960 | https://oxomi.com/p/3000126/datasheet/-/12596251402 | 0.046
1006213 | 20 | 29 | 0.0000058041 | REHAU Compression sleeve RAUT. MX/LX +G 25 | 4007360377519 | 12596251402 | 1960 | https://oxomi.com/p/3000126/datasheet/-/12596251402 | 0.046
1006220 | 25 | 34 | 0.0000131097 | REHAU Compression sleeve RAUT. MX/LX 32 | 4007360168698 | 11371661001 | 1961 | https://oxomi.com/p/3000126/datasheet/-/11371661001 | 0.096
1006222 | 15 | 25 | 0.00000393937 | REHAU Compression sleeve RAUT. MX/LX 20 | 4007360031060 | 12596151002 | 1959 | https://oxomi.com/p/3000126/datasheet/-/12596151002 | 0.028
1006224 | 20 | 29 | 0.0000058041 | REHAU Compression sleeve RAUT. MX/LX +G 25 | 4007360377519 | 12596251402 | 1960 | https://oxomi.com/p/3000126/datasheet/-/12596251402 | 0.046
1007448 | 40 | 44 | 0.0000372872 | REHAU Compression sleeve RAUTITAN MX/LX 50 | 4007360031817 | 11397711002 | 1963 | https://oxomi.com/p/3000126/datasheet/-/11397711002 | 0.293
1007450 | 40 | 44 | 0.0000372872 | REHAU Compression sleeve RAUTITAN MX/LX 50 | 4007360031817 | 11397711002 | 1963 | https://oxomi.com/p/3000126/datasheet/-/11397711002 | 0.293
1007452 | 40 | 44 | 0.0000372872 | REHAU Compression sleeve RAUTITAN MX/LX 50 | 4007360031817 | 11397711002 | 1963 | https://oxomi.com/p/3000126/datasheet/-/11397711002 | 0.293
1007454 | 50 | 53 | 0.0000553035 | REHAU Compression sleeve RAUTITAN MX/LX 63 | 4007360031824 | 11397811002 | 1964 | https://oxomi.com/p/3000126/datasheet/-/11397811002 | 0.439
1007456 | 50 | 53 | 0.0000553035 | REHAU Compression sleeve RAUTITAN MX/LX 63 | 4007360031824 | 11397811002 | 1964 | https://oxomi.com/p/3000126/datasheet/-/11397811002 | 0.439
1007458 | 50 | 53 | 0.0000553035 | REHAU Compression sleeve RAUTITAN MX/LX 63 | 4007360031824 | 11397811002 | 1964 | https://oxomi.com/p/3000126/datasheet/-/11397811002 | 0.439
1007490 | 40 | 44 | 0.0000372872 | REHAU Compression sleeve RAUTITAN MX/LX 50 | 4007360031817 | 11397711002 | 1963 | https://oxomi.com/p/3000126/datasheet/-/11397711002 | 0.293
1007494 | 40 | 44 | 0.0000372872 | REHAU Compression sleeve RAUTITAN MX/LX 50 | 4007360031817 | 11397711002 | 1963 | https://oxomi.com/p/3000126/datasheet/-/11397711002 | 0.293
1007496 | 50 | 53 | 0.0000553035 | REHAU Compression sleeve RAUTITAN MX/LX 63 | 4007360031824 | 11397811002 | 1964 | https://oxomi.com/p/3000126/datasheet/-/11397811002 | 0.439
1007498 | 40 | 44 | 0.0000372872 | REHAU Compression sleeve RAUTITAN MX/LX 50 | 4007360031817 | 11397711002 | 1963 | https://oxomi.com/p/3000126/datasheet/-/11397711002 | 0.293
1007500 | 50 | 53 | 0.0000553035 | REHAU Compression sleeve RAUTITAN MX/LX 63 | 4007360031824 | 11397811002 | 1964 | https://oxomi.com/p/3000126/datasheet/-/11397811002 | 0.439
1007526 | 40 | 44 | 0.0000372872 | REHAU Compression sleeve RAUTITAN MX/LX 50 | 4007360031817 | 11397711002 | 1963 | https://oxomi.com/p/3000126/datasheet/-/11397711002 | 0.293
1007530 | 40 | 44 | 0.0000372872 | REHAU Compression sleeve RAUTITAN MX/LX 50 | 4007360031817 | 11397711002 | 1963 | https://oxomi.com/p/3000126/datasheet/-/11397711002 | 0.293
1007532 | 50 | 53 | 0.0000553035 | REHAU Compression sleeve RAUTITAN MX/LX 63 | 4007360031824 | 11397811002 | 1964 | https://oxomi.com/p/3000126/datasheet/-/11397811002 | 0.439
1007536 | 50 | 53 | 0.0000553035 | REHAU Compression sleeve RAUTITAN MX/LX 63 | 4007360031824 | 11397811002 | 1964 | https://oxomi.com/p/3000126/datasheet/-/11397811002 | 0.439
1007544 | 40 | 44 | 0.0000372872 | REHAU Compression sleeve RAUTITAN MX/LX 50 | 4007360031817 | 11397711002 | 1963 | https://oxomi.com/p/3000126/datasheet/-/11397711002 | 0.293
1007548 | 40 | 44 | 0.0000372872 | REHAU Compression sleeve RAUTITAN MX/LX 50 | 4007360031817 | 11397711002 | 1963 | https://oxomi.com/p/3000126/datasheet/-/11397711002 | 0.293
1007616 | 40 | 44 | 0.0000372872 | REHAU Compression sleeve RAUTITAN MX/LX 50 | 4007360031817 | 11397711002 | 1963 | https://oxomi.com/p/3000126/datasheet/-/11397711002 | 0.293
1067886 | 32 | 37 | 0.0000199643 | REHAU Compression sleeve RAUT. MX/LX 40 | 4007360186487 | 11372961001 | 1962 | https://oxomi.com/p/3000126/datasheet/-/11372961001 | 0.162
1067888 | 25 | 34 | 0.0000131097 | REHAU Compression sleeve RAUT. MX/LX 32 | 4007360168698 | 11371661001 | 1961 | https://oxomi.com/p/3000126/datasheet/-/11371661001 | 0.096
1067892 | 40 | 44 | 0.0000372872 | REHAU Compression sleeve RAUTITAN MX/LX 50 | 4007360031817 | 11397711002 | 1963 | https://oxomi.com/p/3000126/datasheet/-/11397711002 | 0.293
1067894 | 32 | 37 | 0.0000199643 | REHAU Compression sleeve RAUT. MX/LX 40 | 4007360186487 | 11372961001 | 1962 | https://oxomi.com/p/3000126/datasheet/-/11372961001 | 0.162
1067899 | 50 | 53 | 0.0000553035 | REHAU Compression sleeve RAUTITAN MX/LX 63 | 4007360031824 | 11397811002 | 1964 | https://oxomi.com/p/3000126/datasheet/-/11397811002 | 0.439
1067901 | 40 | 44 | 0.0000372872 | REHAU Compression sleeve RAUTITAN MX/LX 50 | 4007360031817 | 11397711002 | 1963 | https://oxomi.com/p/3000126/datasheet/-/11397711002 | 0.293
