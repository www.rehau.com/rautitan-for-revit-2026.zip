Properties of the parts of a building model (IFC4), part 1 of 10

# File
Description: ViewDefinition [DesignTransferView_V1.0], RevitIdentifiers [ContentGUID: e089795b-051c-4659-b85b-e6398c43f6c2, VersionGUID: 32b5a587-afeb-4251-a5f7-020251c14f7c, NumberOfSaves: 3], CoordinateReference [CoordinateBase: Shared Coordinates, ProjectSite: Default Site], ExchangeRequirement [BuildingService]
File name: IFC4 DTV RAUTITAN Gallery.ifc
Time: 2026-02-11T16:14:22+01:00
Written by: ODA SDAI 25.12
Made in: Autodesk - Revit 26.4.0.32 (ENG) - 26.4.0.32

# IfcSite, Default
RefLatitude: 42, 24, 53, 508911; RefLongitude: -71, -15, -29, -58837; RefElevation: 0 mm
Pset_SiteCommon - Reference: Project Information
Other - Category: Project Information

# IfcBuilding
Pset_BuildingCommon - Reference: Project Information; NumberOfStoreys: 1
Other - Category: Project Information

# IfcBuildingStorey, REHAU Starting view
LongName: REHAU Starting view; Elevation: 0 mm
Pset_BuildingStoreyCommon - Reference: Level:Level 1
Other - Category: Levels; Family: Level; Family and Type: Level: Level 1; Type: Level 1; Type Id: 1813
Constraints - Elevation: 0 mm
Dimensions - Computation Height: 0 mm
Identity Data - Building Story: yes; Name: REHAU Starting view; Structural: no
Other(Type) - Category: Levels; Family Name: Level
Constraints(Type) - Elevation Base: Project Base Point
Graphics(Type) - Color: 0; Line Pattern: Solid; Line Weight: 1; Symbol at End 1 Default: no; Symbol at End 2 Default: yes
Identity Data(Type) - Type Name: Level 1

# IfcBuildingElementProxy: Model Text:Model Text 1 (64)
In: REHAU Starting view
Type - Other - Category: Generic Models; Family Name: Model Text
Type - Identity Data - Type Name: Model Text 1
Type - Text - Bold: no; Italic: no; Text Font: Arial; Text Size: 40 mm
Pset_BuildingElementProxyCommon - Reference: Model Text:Model Text 1; IsExternal: no
Pset_EnvironmentalImpactIndicators - Reference: Model Text:Model Text 1
Other - Family: Model Text; Family and Type: Model Text: Model Text 1; Type: Model Text 1; Type Id: 1886
Constraints - Work Plane: Level : REHAU Starting view
Dimensions - Depth: 5 mm
Graphics - Horizontal Align: Left
Identity Data - Subcategory: Generic Models
Phasing - Phase Created: New Construction
Name (Model Text:Model Text 1:...) | Text | Material
972961 | DN 10 | RAUTITAN PX
973093 | DN 12 | RAUTITAN PX
973101 | DN 15 | RAUTITAN PX
973109 | DN 20 | RAUTITAN PX
973117 | DN 25 | RAUTITAN PX
973125 | DN 32 | RAUTITAN PX
973133 | DN 40 | RAUTITAN PX
973141 | DN 50 | RAUTITAN PX
973152 | RAUTITAN LX Fitting with MX/LX Sleeve & RAUTITAN LX Fitting with PX Sleeve | RAUTITAN PX
973381 | *Note, LX Fitting connection sizes DN/Do 40/50 & 50/63 only compatible with RAUTITAN Flex Pipes and MX/LX Sleeve *Note, LX Fittings are only compatible for Drinking water in The Netherlands & Italy | Error
1078174 | DN 12 | RAUTITAN PX
1078175 | DN 15 | RAUTITAN PX
1078176 | DN 20 | RAUTITAN PX
1078177 | DN 25 | RAUTITAN PX
1078178 | DN 32 | RAUTITAN PX
1078179 | DN 40 | RAUTITAN PX
1078180 | DN 50 | RAUTITAN PX
1078353 | RAUTITAN PX Fitting with PX Sleeve & RAUTITAN RX+ stabil Fitting with PX stabil&PX Sleeve | RAUTITAN PX
1078354 | *Note, RX+ stabil Fitting connection sizes DN/Do 40/50 & 50/63 only compatible with RAUTITAN stabil pipes | Error
1078363 | DN 12 | RAUTITAN PX
1078364 | DN 15 | RAUTITAN PX
1078365 | DN 20 | RAUTITAN PX
1078366 | DN 25 | RAUTITAN PX
1078367 | DN 32 | RAUTITAN PX
1078368 | DN 40 | RAUTITAN PX
1078369 | DN 50 | RAUTITAN PX
1078374 | RAUTITAN RX+ Fitting with PX flex & PX Sleeve | RAUTITAN PX
1078375 | *Note, RX+ Fitting connection sizes DN/Do 40/50 & 50/63 only compatible with RAUTITAN flex pipes | Error
1149345 | RAUTITAN Stabil LX & RX+ stabil DN | RAUTITAN PX
1149346 | RAUTITAN flex LX & RX+ DN | RAUTITAN PX
1150123 | DN 10 | RAUTITAN PX
1150164 | DN 12 | RAUTITAN PX
1150180 | DN 15 | RAUTITAN PX
1150200 | DN 20 | RAUTITAN PX
1150201 | DN 25 | RAUTITAN PX
1150202 | DN 32 | RAUTITAN PX
1150203 | DN 40 | RAUTITAN PX
1150204 | DN 50 | RAUTITAN PX
1150373 | RAUTITAN Stabil PX & RX+ Stabil DN | RAUTITAN PX
1150497 | RAUTITAN Flex PX & RX+ DN | RAUTITAN PX
1150840 | RAUTITAN Stabil LX & RX+ Stabil Do | RAUTITAN PX
1150841 | RAUTITAN Flex LX & RX+ Do | RAUTITAN PX
1150870 | Do 12 | RAUTITAN PX
1150871 | Do 16 | RAUTITAN PX
1150872 | Do 20 | RAUTITAN PX
1150873 | Do 25 | RAUTITAN PX
1150874 | Do 32 | RAUTITAN PX
1150875 | Do 40 | RAUTITAN PX
1150876 | Do 50 | RAUTITAN PX
1150877 | Do 63 | RAUTITAN PX
1150880 | RAUTITAN Stabil PX & RX+ Stabil Do | RAUTITAN PX
1150893 | RAUTITAN Flex PX & RX+ Do | RAUTITAN PX
1239751 | Bath & Laundry essemblies (Only for Australia) | RAUTITAN PX
1442075 | DN 12 | RAUTITAN PX
1442076 | DN 15 | RAUTITAN PX
1442077 | DN 20 | RAUTITAN PX
1442078 | DN 25 | RAUTITAN PX
1442079 | DN 32 | RAUTITAN PX
1442080 | DN 40 | RAUTITAN PX
1442081 | DN 50 | RAUTITAN PX
1447732 | DN 12 | RAUTITAN PX
1447733 | DN 15 | RAUTITAN PX
1447734 | DN 20 | RAUTITAN PX
1447735 | DN 25 | RAUTITAN PX

# IfcBuildingElementProxy: RAUTITAN_WM_Corner_RP_LX:12 Rp 1/2 short, RAUTITAN_WM_Corner_RP_LX:12 Rp 1/2 short:1087087
In: REHAU Starting view
Type - Material: Brass
Type - Other - Category: Plumbing Equipment; Backplate: yes; Backplate 01: yes; Backplate 02: no; Family Name: RAUTITAN_WM_Corner_RP_LX; Frontplate: no; L4: 29.3 mm; L5: 40.5 mm; L6: 16.5 mm; r1: 8.95 mm; r2: 6.25 mm; r3: 13.5 mm; r4: 9.5 mm; s1: 4 mm; T1: RTI WM Corner RP LX P1; T2: RTI WM Corner RP LX; Z2: 2.7 mm; Z4: 23 mm; Z5: 12 mm
Type - Constraints - Default Elevation: 0 mm
Type - Data - Language: Description EN; Region Check: Check NL; Region PID: PID NL; Type: Short
Type - Dimensions - Di1: 6.6 mm; Di2: 12.5 mm; Di3: 19 mm; DN1: 10 mm; DN2: 15 mm; Do2: 17.9 mm; Do3: 27 mm
Type - Identity Data - Classification Number: 23.60.30.11.14; Manufacturer: REHAU; Model: RAUTITAN; Type Name: 12 Rp 1/2 short
Type - Pset_ManufacturerTypeInformation - Manufacturer: REHAU
Pset_BuildingElementProxyCommon - IsExternal: no; Reference: RAUTITAN_WM_Corner_RP_LX:12 Rp 1/2 short
Pset_EnvironmentalImpactIndicators - Reference: RAUTITAN_WM_Corner_RP_LX:12 Rp 1/2 short
Other - IsCustom: no; Family: RAUTITAN_WM_Corner_RP_LX; Family and Type: RAUTITAN_WM_Corner_RP_LX: 12 Rp 1/2 short; Type: 12 Rp 1/2 short; Type Id: 1089502
Constraints - Elevation from Level: 0 mm; Level: REHAU Starting view; Host: Level : REHAU Starting view; Offset from Host: 0 mm
Data - PID Check: 1 mm
Dimensions - Area: 0.0115702 m2; Volume: 0.0000260856 m3
Identity Data - Description long: REHAU Wall-elbow RAUTITAN LX 12 - Rp 1/2 short; GTIN: 4007360633042; Mark: 8; PID: 11681231008; Weight: 114
Mechanical - System Classification: Domestic Cold Water
Phasing - Phase Created: New Construction

# IfcBuildingElementProxy: RAUTITAN_WM_Corner_RP_LX:16 Rp 1/2 long, RAUTITAN_WM_Corner_RP_LX:16 Rp 1/2 long:1087090
In: REHAU Starting view
Type - Material: Brass
Type - Other - Category: Plumbing Equipment; Backplate: yes; Backplate 01: yes; Backplate 02: no; Frontplate: no; Family Name: RAUTITAN_WM_Corner_RP_LX; L4: 41.8 mm; L5: 55 mm; L6: 29.5 mm; r1: 9.35 mm; r2: 6.25 mm; r3: 13.5 mm; r4: 9.5 mm; s1: 4 mm; T1: RTI WM Corner RP LX P1; T2: RTI WM Corner RP LX; Z2: 3.1 mm; Z4: 24.3 mm; Z5: 16.1 mm
Type - Constraints - Default Elevation: 0 mm
Type - Data - Language: Description EN; Region Check: Check NL; Region PID: PID NL; Type: Long
Type - Dimensions - Di1: 9.9 mm; Di2: 12.5 mm; Di3: 19 mm; DN1: 12 mm; DN2: 15 mm; Do2: 18.7 mm; Do3: 27 mm
Type - Identity Data - Classification Number: 23.60.30.11.14; Manufacturer: REHAU; Model: RAUTITAN; Type Name: 16 Rp 1/2 long
Type - Pset_ManufacturerTypeInformation - Manufacturer: REHAU
Pset_BuildingElementProxyCommon - IsExternal: no; Reference: RAUTITAN_WM_Corner_RP_LX:16 Rp 1/2 long
Pset_EnvironmentalImpactIndicators - Reference: RAUTITAN_WM_Corner_RP_LX:16 Rp 1/2 long
Other - IsCustom: no; Family: RAUTITAN_WM_Corner_RP_LX; Family and Type: RAUTITAN_WM_Corner_RP_LX: 16 Rp 1/2 long; Type: 16 Rp 1/2 long; Type Id: 1089493
Constraints - Elevation from Level: 0 mm; Level: REHAU Starting view; Offset from Host: 0 mm; Host: Level : REHAU Starting view
Data - PID Check: 1 mm
Dimensions - Area: 0.0131544 m2; Volume: 0.0000318449 m3
Identity Data - Description long: REHAU Wall-elbow RAUTITAN LX 16 - Rp 1/2 long; GTIN: 4007360633059; Mark: 9; PID: 11681261008; Weight: 155
Mechanical - System Classification: Domestic Cold Water
Phasing - Phase Created: New Construction

# IfcBuildingElementProxy: RAUTITAN_WM_Corner_RP_LX:16 Rp 1/2 plasterboard, RAUTITAN_WM_Corner_RP_LX:16 Rp 1/2 plasterboard:1087093
In: REHAU Starting view
Type - Material: Brass
Type - Other - Category: Plumbing Equipment; Backplate 02: no; Backplate: no; Backplate 01: no; Family Name: RAUTITAN_WM_Corner_RP_LX; Frontplate: yes; L4: 27.3 mm; L5: 40.5 mm; L6: 16.5 mm; r1: 9.35 mm; r2: 6.25 mm; r3: 13.5 mm; r4: 9.5 mm; s1: 4 mm; T1: RTI WM Corner RP LX P1; T2: RTI WM Corner RP LX; Z2: 3.1 mm; Z4: 24.3 mm; Z5: 16.1 mm
Type - Constraints - Default Elevation: 0 mm
Type - Data - Language: Description EN; Region Check: Check NL; Region PID: PID NL; Type: Plasterboard
Type - Dimensions - Di1: 9.9 mm; Di2: 12.5 mm; Di3: 19 mm; DN1: 12 mm; DN2: 15 mm; Do2: 18.7 mm; Do3: 27 mm
Type - Identity Data - Classification Number: 23.60.30.11.14; Manufacturer: REHAU; Model: RAUTITAN; Type Name: 16 Rp 1/2 plasterboard
Type - Pset_ManufacturerTypeInformation - Manufacturer: REHAU
Pset_BuildingElementProxyCommon - IsExternal: no; Reference: RAUTITAN_WM_Corner_RP_LX:16 Rp 1/2 plasterboard
Pset_EnvironmentalImpactIndicators - Reference: RAUTITAN_WM_Corner_RP_LX:16 Rp 1/2 plasterboard
Other - IsCustom: no; Family: RAUTITAN_WM_Corner_RP_LX; Family and Type: RAUTITAN_WM_Corner_RP_LX: 16 Rp 1/2 plasterboard; Type: 16 Rp 1/2 plasterboard; Type Id: 1089500
Constraints - Elevation from Level: 0 mm; Level: REHAU Starting view; Offset from Host: 0 mm; Host: Level : REHAU Starting view
Data - PID Check: 1 mm
Dimensions - Area: 0.0121415 m2; Volume: 0.0000276597 m3
Identity Data - Description long: REHAU Wall-moun. elbow RAUTITAN LX 16 - Rp 1/2 for plasterboard; GTIN: 4007360458607; Mark: 10; PID: 11681361001; Weight: 221
Mechanical - System Classification: Domestic Cold Water
Phasing - Phase Created: New Construction

# IfcBuildingElementProxy: RAUTITAN_WM_Corner_RP_LX:16 Rp 1/2 short, RAUTITAN_WM_Corner_RP_LX:16 Rp 1/2 short:1087096
In: REHAU Starting view
Type - Material: Brass
Type - Other - Category: Plumbing Equipment; Backplate: yes; Backplate 01: yes; Backplate 02: no; Frontplate: no; Family Name: RAUTITAN_WM_Corner_RP_LX; L4: 27.3 mm; L5: 40.5 mm; L6: 16.5 mm; r1: 9.35 mm; r2: 6.25 mm; r3: 13.5 mm; r4: 9.5 mm; s1: 4 mm; T1: RTI WM Corner RP LX P1; T2: RTI WM Corner RP LX; Z2: 3.1 mm; Z4: 24.3 mm; Z5: 16.1 mm
Type - Constraints - Default Elevation: 0 mm
Type - Data - Language: Description EN; Region Check: Check NL; Region PID: PID NL; Type: Short
Type - Dimensions - Di1: 9.9 mm; Di2: 12.5 mm; Di3: 19 mm; DN1: 12 mm; DN2: 15 mm; Do2: 18.7 mm; Do3: 27 mm
Type - Identity Data - Classification Number: 23.60.30.11.14; Manufacturer: REHAU; Model: RAUTITAN; Type Name: 16 Rp 1/2 short
Type - Pset_ManufacturerTypeInformation - Manufacturer: REHAU
Pset_BuildingElementProxyCommon - IsExternal: no; Reference: RAUTITAN_WM_Corner_RP_LX:16 Rp 1/2 short
Pset_EnvironmentalImpactIndicators - Reference: RAUTITAN_WM_Corner_RP_LX:16 Rp 1/2 short
Other - IsCustom: no; Family: RAUTITAN_WM_Corner_RP_LX; Family and Type: RAUTITAN_WM_Corner_RP_LX: 16 Rp 1/2 short; Type: 16 Rp 1/2 short; Type Id: 1089494
Constraints - Elevation from Level: 0 mm; Level: REHAU Starting view; Offset from Host: 0 mm; Host: Level : REHAU Starting view
Data - PID Check: 1 mm
Dimensions - Area: 0.0121415 m2; Volume: 0.0000278436 m3
Identity Data - Description long: REHAU Wall-elbow RAUTITAN LX +G 16 - Rp 1/2 short; GTIN: 4007360633004; Mark: 11; PID: 13130721008; Weight: 115
Mechanical - System Classification: Domestic Cold Water
Phasing - Phase Created: New Construction

# IfcBuildingElementProxy: RAUTITAN_WM_Corner_RP_LX:16 Rp 1/2 squared, RAUTITAN_WM_Corner_RP_LX:16 Rp 1/2 squared:1087099
In: REHAU Starting view
Type - Material: Brass
Type - Other - Category: Plumbing Equipment; Backplate: yes; Frontplate: no; Backplate 01: no; Backplate 02: yes; Family Name: RAUTITAN_WM_Corner_RP_LX; L4: 27.3 mm; L5: 40.5 mm; L6: 16.5 mm; r1: 9.35 mm; r2: 6.25 mm; r3: 13.5 mm; r4: 9.5 mm; s1: 4 mm; T1: RTI WM Corner RP LX P1; T2: RTI WM Corner RP LX; Z2: 3.1 mm; Z4: 24.3 mm; Z5: 16.1 mm
Type - Constraints - Default Elevation: 0 mm
Type - Data - Language: Description EN; Region Check: Check NL; Region PID: PID NL; Type: Squared
Type - Dimensions - Di1: 9.9 mm; Di2: 12.5 mm; Di3: 19 mm; DN1: 12 mm; DN2: 15 mm; Do2: 18.7 mm; Do3: 27 mm
Type - Identity Data - Classification Number: 23.60.30.11.14; Manufacturer: REHAU; Model: RAUTITAN; Type Name: 16 Rp 1/2 squared
Type - Pset_ManufacturerTypeInformation - Manufacturer: REHAU
Pset_BuildingElementProxyCommon - IsExternal: no; Reference: RAUTITAN_WM_Corner_RP_LX:16 Rp 1/2 squared
Pset_EnvironmentalImpactIndicators - Reference: RAUTITAN_WM_Corner_RP_LX:16 Rp 1/2 squared
Other - IsCustom: no; Family: RAUTITAN_WM_Corner_RP_LX; Family and Type: RAUTITAN_WM_Corner_RP_LX: 16 Rp 1/2 squared; Type: 16 Rp 1/2 squared; Type Id: 1089501
Constraints - Elevation from Level: 0 mm; Level: REHAU Starting view; Offset from Host: 0 mm; Host: Level : REHAU Starting view
Data - PID Check: 1 mm
Dimensions - Area: 0.0121415 m2; Volume: 0.0000278436 m3
Identity Data - Description long: REHAU Wall-moun. elbow RAUTITAN LX 16 - Rp 1/2 with square backplate; GTIN: 4007360458645; Mark: 12; PID: 11681401001; Weight: 137
Mechanical - System Classification: Domestic Cold Water
Phasing - Phase Created: New Construction

# IfcBuildingElementProxy: RAUTITAN_WM_Corner_RP_LX:16 Rp 3/8 short, RAUTITAN_WM_Corner_RP_LX:16 Rp 3/8 short:1087102
In: REHAU Starting view
Type - Material: Brass
Type - Other - Category: Plumbing Equipment; Backplate: yes; Backplate 01: yes; Backplate 02: no; Frontplate: no; Family Name: RAUTITAN_WM_Corner_RP_LX; L4: 23.3 mm; L5: 36.5 mm; L6: 13 mm; r1: 9.35 mm; r2: 6.25 mm; r3: 11.5 mm; r4: 7.55 mm; s1: 3.95 mm; T1: RTI WM Corner RP LX P1; T2: RTI WM Corner RP LX; Z2: 3.1 mm; Z4: 22.3 mm; Z5: 16.1 mm
Type - Constraints - Default Elevation: 0 mm
Type - Data - Language: Description EN; Region Check: Check NL; Region PID: PID NL; Type: Short
Type - Dimensions - Di1: 9.9 mm; Di2: 12.5 mm; Di3: 15.1 mm; DN1: 12 mm; DN2: 10 mm; Do2: 18.7 mm; Do3: 23 mm
Type - Identity Data - Classification Number: 23.60.30.11.14; Manufacturer: REHAU; Model: RAUTITAN; Type Name: 16 Rp 3/8 short
Type - Pset_ManufacturerTypeInformation - Manufacturer: REHAU
Pset_BuildingElementProxyCommon - IsExternal: no; Reference: RAUTITAN_WM_Corner_RP_LX:16 Rp 3/8 short
Pset_EnvironmentalImpactIndicators - Reference: RAUTITAN_WM_Corner_RP_LX:16 Rp 3/8 short
Other - IsCustom: no; Family: RAUTITAN_WM_Corner_RP_LX; Family and Type: RAUTITAN_WM_Corner_RP_LX: 16 Rp 3/8 short; Type: 16 Rp 3/8 short; Type Id: 1089495
Constraints - Elevation from Level: 0 mm; Level: REHAU Starting view; Offset from Host: 0 mm; Host: Level : REHAU Starting view
Data - PID Check: 1 mm
Dimensions - Area: 0.0115086 m2; Volume: 0.0000253825 m3
Identity Data - Description long: REHAU Wall-elbow RAUTITAN LX 16 - Rp 3/8 short; GTIN: 4007360633080; Mark: 13; PID: 11681281008; Weight: 94
Mechanical - System Classification: Domestic Cold Water
Phasing - Phase Created: New Construction

# IfcBuildingElementProxy: RAUTITAN_WM_Corner_RP_LX:20 Rp 1/2 long, RAUTITAN_WM_Corner_RP_LX:20 Rp 1/2 long:1087105
In: REHAU Starting view
Type - Material: Brass
Type - Other - Category: Plumbing Equipment; Backplate: yes; Backplate 01: yes; Backplate 02: no; Frontplate: no; Family Name: RAUTITAN_WM_Corner_RP_LX; L4: 39.8 mm; L5: 55.1 mm; L6: 29.5 mm; r1: 10.05 mm; r2: 6.25 mm; r3: 13.5 mm; r4: 9.5 mm; s1: 4 mm; T1: RTI WM Corner RP LX P1; T2: RTI WM Corner RP LX; Z2: 3.8 mm; Z4: 24.8 mm; Z5: 20.1 mm
Type - Constraints - Default Elevation: 0 mm
Type - Data - Language: Description EN; Region Check: Check NL; Region PID: PID NL; Type: Long
Type - Dimensions - Di1: 12.5 mm; Di2: 12.5 mm; Di3: 19 mm; DN1: 15 mm; DN2: 15 mm; Do2: 20.1 mm; Do3: 27 mm
Type - Identity Data - Classification Number: 23.60.30.11.14; Manufacturer: REHAU; Model: RAUTITAN; Type Name: 20 Rp 1/2 long
Type - Pset_ManufacturerTypeInformation - Manufacturer: REHAU
Pset_BuildingElementProxyCommon - IsExternal: no; Reference: RAUTITAN_WM_Corner_RP_LX:20 Rp 1/2 long
Pset_EnvironmentalImpactIndicators - Reference: RAUTITAN_WM_Corner_RP_LX:20 Rp 1/2 long
Other - IsCustom: no; Family: RAUTITAN_WM_Corner_RP_LX; Family and Type: RAUTITAN_WM_Corner_RP_LX: 20 Rp 1/2 long; Type: 20 Rp 1/2 long; Type Id: 1089496
Constraints - Elevation from Level: 0 mm; Level: REHAU Starting view; Offset from Host: 0 mm; Host: Level : REHAU Starting view
Data - PID Check: 1 mm
Dimensions - Area: 0.0136559 m2; Volume: 0.0000342705 m3
Identity Data - Description long: REHAU Wall-elbow RAUTITAN LX 20 - Rp 1/2 long; GTIN: 4007360633066; Mark: 14; PID: 11681321008; Weight: 171
Mechanical - System Classification: Domestic Cold Water
Phasing - Phase Created: New Construction

# IfcBuildingElementProxy: RAUTITAN_WM_Corner_RP_LX:20 Rp 1/2 short, RAUTITAN_WM_Corner_RP_LX:20 Rp 1/2 short:1087108
In: REHAU Starting view
Type - Material: Brass
Type - Other - Category: Plumbing Equipment; Backplate: yes; Backplate 01: yes; Backplate 02: no; Frontplate: no; Family Name: RAUTITAN_WM_Corner_RP_LX; L4: 25 mm; L5: 40.3 mm; L6: 16.5 mm; r1: 10.05 mm; r2: 6.25 mm; r3: 13.5 mm; r4: 9.5 mm; s1: 4 mm; T1: RTI WM Corner RP LX P1; T2: RTI WM Corner RP LX; Z2: 3.8 mm; Z4: 24.8 mm; Z5: 20.1 mm
Type - Constraints - Default Elevation: 0 mm
Type - Data - Language: Description EN; Region Check: Check NL; Region PID: PID NL; Type: Short
Type - Dimensions - Di1: 12.5 mm; Di2: 12.5 mm; Di3: 19 mm; DN1: 15 mm; DN2: 15 mm; Do2: 20.1 mm; Do3: 27 mm
Type - Identity Data - Classification Number: 23.60.30.11.14; Manufacturer: REHAU; Model: RAUTITAN; Type Name: 20 Rp 1/2 short
Type - Pset_ManufacturerTypeInformation - Manufacturer: REHAU
Pset_BuildingElementProxyCommon - IsExternal: no; Reference: RAUTITAN_WM_Corner_RP_LX:20 Rp 1/2 short
Pset_EnvironmentalImpactIndicators - Reference: RAUTITAN_WM_Corner_RP_LX:20 Rp 1/2 short
Other - IsCustom: no; Family: RAUTITAN_WM_Corner_RP_LX; Family and Type: RAUTITAN_WM_Corner_RP_LX: 20 Rp 1/2 short; Type: 20 Rp 1/2 short; Type Id: 1089497
Constraints - Elevation from Level: 0 mm; Level: REHAU Starting view; Offset from Host: 0 mm; Host: Level : REHAU Starting view
Data - PID Check: 1 mm
Dimensions - Area: 0.0126028 m2; Volume: 0.0000300777 m3
Identity Data - Description long: REHAU Wall-elbow RAUTITAN LX +G 20 - Rp 1/2 short; GTIN: 4007360633011; Mark: 15; PID: 13130731008; Weight: 133
Mechanical - System Classification: Domestic Cold Water
Phasing - Phase Created: New Construction

# IfcBuildingElementProxy: RAUTITAN_WM_Corner_RP_LX:20 Rp 3/4 short, RAUTITAN_WM_Corner_RP_LX:20 Rp 3/4 short:1087111
In: REHAU Starting view
Type - Material: Brass
Type - Other - Category: Plumbing Equipment; Backplate: yes; Backplate 01: yes; Backplate 02: no; Frontplate: no; Family Name: RAUTITAN_WM_Corner_RP_LX; L4: 25.8 mm; L5: 41 mm; L6: 18.3 mm; r1: 10.05 mm; r2: 6.25 mm; r3: 17 mm; r4: 12.25 mm; s1: 4.75 mm; T1: RTI WM Corner RP LX P1; T2: RTI WM Corner RP LX; Z2: 3.8 mm; Z4: 27.2 mm; Z5: 20.1 mm
Type - Constraints - Default Elevation: 0 mm
Type - Data - Language: Description EN; Region Check: Check NL; Region PID: PID NL; Type: Short
Type - Dimensions - Di1: 12.5 mm; Di2: 12.5 mm; Di3: 24.5 mm; DN1: 15 mm; DN2: 20 mm; Do2: 20.1 mm; Do3: 34 mm
Type - Identity Data - Classification Number: 23.60.30.11.14; Manufacturer: REHAU; Model: RAUTITAN; Type Name: 20 Rp 3/4 short
Type - Pset_ManufacturerTypeInformation - Manufacturer: REHAU
Pset_BuildingElementProxyCommon - IsExternal: no; Reference: RAUTITAN_WM_Corner_RP_LX:20 Rp 3/4 short
Pset_EnvironmentalImpactIndicators - Reference: RAUTITAN_WM_Corner_RP_LX:20 Rp 3/4 short
Other - IsCustom: no; Family: RAUTITAN_WM_Corner_RP_LX; Family and Type: RAUTITAN_WM_Corner_RP_LX: 20 Rp 3/4 short; Type: 20 Rp 3/4 short; Type Id: 1089498
Constraints - Elevation from Level: 0 mm; Level: REHAU Starting view; Offset from Host: 0 mm; Host: Level : REHAU Starting view
Data - PID Check: 1 mm
Dimensions - Area: 0.0133422 m2; Volume: 0.0000342184 m3
Identity Data - Description long: REHAU Wall-elbow RAUTITAN LX +G 20 - Rp 3/4 short; GTIN: 4007360633028; Mark: 16; PID: 13130741008; Weight: 163
Mechanical - System Classification: Domestic Cold Water
Phasing - Phase Created: New Construction

# IfcBuildingElementProxy: RAUTITAN_WM_Corner_RP_LX:25 Rp 3/4 short, RAUTITAN_WM_Corner_RP_LX:25 Rp 3/4 short:1087114
In: REHAU Starting view
Type - Material: Brass
Type - Other - Category: Plumbing Equipment; Backplate: yes; Backplate 01: yes; Backplate 02: no; Frontplate: no; Family Name: RAUTITAN_WM_Corner_RP_LX; L4: 30.1 mm; L5: 47 mm; L6: 17.7 mm; r1: 12.5 mm; r2: 7.6 mm; r3: 17 mm; r4: 12.25 mm; s1: 4.75 mm; T1: RTI WM Corner RP LX P1; T2: RTI WM Corner RP LX; Z2: 4.9 mm; Z4: 27.6 mm; Z5: 25 mm
Type - Constraints - Default Elevation: 0 mm
Type - Data - Language: Description EN; Region Check: Check NL; Region PID: PID NL; Type: Short
Type - Dimensions - Di1: 15.2 mm; Di2: 15.2 mm; Di3: 24.5 mm; DN1: 20 mm; DN2: 20 mm; Do2: 25 mm; Do3: 34 mm
Type - Identity Data - Classification Number: 23.60.30.11.14; Manufacturer: REHAU; Model: RAUTITAN; Type Name: 25 Rp 3/4 short
Type - Pset_ManufacturerTypeInformation - Manufacturer: REHAU
Pset_BuildingElementProxyCommon - IsExternal: no; Reference: RAUTITAN_WM_Corner_RP_LX:25 Rp 3/4 short
Pset_EnvironmentalImpactIndicators - Reference: RAUTITAN_WM_Corner_RP_LX:25 Rp 3/4 short
Other - IsCustom: no; Family: RAUTITAN_WM_Corner_RP_LX; Family and Type: RAUTITAN_WM_Corner_RP_LX: 25 Rp 3/4 short; Type: 25 Rp 3/4 short; Type Id: 1089499
Constraints - Elevation from Level: 0 mm; Level: REHAU Starting view; Offset from Host: 0 mm; Host: Level : REHAU Starting view
Data - PID Check: 1 mm
Dimensions - Area: 0.01463 m2; Volume: 0.0000406525 m3
Identity Data - Description long: REHAU Wall-elbow RAUTITAN LX +G 25 - Rp 3/4 short; GTIN: 4007360633035; Mark: 17; PID: 13130751008; Weight: 204
Mechanical - System Classification: Domestic Cold Water
Phasing - Phase Created: New Construction

# IfcBuildingElementProxy: REHAU_RAUTITAN_Bracket 75 150:REHAU_RAUTITAN_Bracket 75 150, Halter E
In: REHAU Starting view
Type - Material: <Unnamed>
Type - Other - Category: Mechanical Equipment; Family Name: REHAU_RAUTITAN_Bracket 75 150
Type - Constraints - Default Elevation: 0 mm
Type - Data - ETIM_Number of wall plate locations: 2; ETIM_Material mounting profile: Steel; ETIM_Model: Double flat; ETIM_Surface protection: Hot-dip galvanized
Type - Identity Data - REH_DESCRIPTION_LANGUAGE: Language : EN; Classification Number: 23.27.43.13; ETIM_CLASS: EC010108; ETIM_MODELLING_CLASS: N/A; Manufacturer: REHAU; REH_BIM_SUPPORT: bim@rehau.com; REH_INFO: 2022.11.04-416508-416508; REH_PRICE_LIST: DE_2022; REH_PRODUCT_PICTURE: https://static.rehau.com/bim/images/1000/jpg/M-53216877.jpg; Type Name: REHAU_RAUTITAN_Bracket 75 150; URL: www.rehau.com
Type - Pset_ManufacturerTypeInformation - Manufacturer: REHAU
Description: REHAU Bracket 75/150, for double connection
Pset_BuildingElementProxyCommon - IsExternal: no; Reference: REHAU_RAUTITAN_Bracket 75 150:REHAU_RAUTITAN_Bracket 75 150
Pset_EnvironmentalImpactIndicators - Reference: REHAU_RAUTITAN_Bracket 75 150:REHAU_RAUTITAN_Bracket 75 150
Other - Family: REHAU_RAUTITAN_Bracket 75 150; Family and Type: REHAU_RAUTITAN_Bracket 75 150: REHAU_RAUTITAN_Bracket 75 150; Type: REHAU_RAUTITAN_Bracket 75 150; Type Id: 1311319
Constraints - Elevation from Level: 0 mm; Level: REHAU Starting view; Moves With Nearby Elements: no; Offset from Host: 0 mm; Host: Level : REHAU Starting view
Dimensions - a: 338 mm; Area: 0.0137867 m2; b: 40 mm; c: 150 mm; d: 75 mm; Volume: 0.0000334598 m3
Identity Data - Mark: 86; PID: 11055361008; REH_DESCRIPTION_SHORT: REHAU Bracket 75/150, for double connection; REH_GTIN: 4007360629410; REH_NETWEIGHT_G/PC: 254; REH_SUPPLIER_PID: 11055361008
Phasing - Phase Created: New Construction

# IfcBuildingElementProxy: REHAU_RAUTITAN_Bracket D:REHAU_RAUTITAN_Bracket D, Halter O 100
In: REHAU Starting view
Type - Material: <Unnamed>
Type - Other - Category: Mechanical Equipment; Family Name: REHAU_RAUTITAN_Bracket D
Type - Constraints - Default Elevation: 0 mm
Type - Data - ETIM_Number of wall plate locations: 2; ETIM_Material mounting profile: Steel; ETIM_Model: Double bridge; ETIM_Surface protection: Hot-dip galvanized
Type - Identity Data - REH_DESCRIPTION_LANGUAGE: Language : EN; Classification Number: 23.27.43.13; ETIM_CLASS: EC010108; ETIM_MODELLING_CLASS: N/A; Manufacturer: REHAU; REH_BIM_SUPPORT: bim@rehau.com; REH_INFO: 2022.10.27-416508-416508; REH_PRICE_LIST: DE_2022; REH_PRODUCT_PICTURE: https://static.rehau.com/bim/images/1000/jpg/M-13585183.jpg; Type Name: REHAU_RAUTITAN_Bracket D; URL: www.rehau.com
Type - Pset_ManufacturerTypeInformation - Manufacturer: REHAU
Description: REHAU Bracket D, for double connection
Pset_BuildingElementProxyCommon - IsExternal: no; Reference: REHAU_RAUTITAN_Bracket D:REHAU_RAUTITAN_Bracket D
Pset_EnvironmentalImpactIndicators - Reference: REHAU_RAUTITAN_Bracket D:REHAU_RAUTITAN_Bracket D
Other - Family: REHAU_RAUTITAN_Bracket D; Family and Type: REHAU_RAUTITAN_Bracket D: REHAU_RAUTITAN_Bracket D; Type: REHAU_RAUTITAN_Bracket D; Type Id: 1313960
Constraints - Elevation from Level: 0 mm; Level: REHAU Starting view; Moves With Nearby Elements: no; Offset from Host: 0 mm; Host: Level : REHAU Starting view
Dimensions - a: 418 mm; Area: 0.0277094 m2; b: 30 mm; c: 33 mm; d: 55 mm; Volume: 0.0000611871 m3
Identity Data - Mark: 87; PID: 11055341008; REH_DESCRIPTION_SHORT: REHAU Bracket D, for double connection; REH_GTIN: 4007360628598; REH_NETWEIGHT_G/PC: 443; REH_SUPPLIER_PID: 11055341008
Phasing - Phase Created: New Construction

# IfcBuildingElementProxy: REHAU_RAUTITAN_Bracket E:REHAU_RAUTITAN_Bracket E, Halter E
In: REHAU Starting view
Type - Material: <Unnamed>
Type - Other - Category: Mechanical Equipment; Family Name: REHAU_RAUTITAN_Bracket E
Type - Constraints - Default Elevation: 0 mm
Type - Data - ETIM_Material mounting profile: Steel; ETIM_Model: Single; ETIM_Number of wall plate locations: 1; ETIM_Surface protection: Hot-dip galvanized
Type - Identity Data - REH_DESCRIPTION_LANGUAGE: Language : EN; Classification Number: 23.27.43.13; ETIM_CLASS: EC010108; ETIM_MODELLING_CLASS: N/A; Manufacturer: REHAU; REH_BIM_SUPPORT: bim@rehau.com; REH_INFO: 2022.11.04-416508-416508; REH_PRICE_LIST: DE_2022; REH_PRODUCT_PICTURE: https://static.rehau.com/bim/images/1000/jpg/M-53216914.jpg; Type Name: REHAU_RAUTITAN_Bracket E; URL: www.rehau.com
Type - Pset_ManufacturerTypeInformation - Manufacturer: REHAU
Description: REHAU Halter E, für Einzelanschluss
Pset_BuildingElementProxyCommon - IsExternal: no; Reference: REHAU_RAUTITAN_Bracket E:REHAU_RAUTITAN_Bracket E
Pset_EnvironmentalImpactIndicators - Reference: REHAU_RAUTITAN_Bracket E:REHAU_RAUTITAN_Bracket E
Other - Family: REHAU_RAUTITAN_Bracket E; Family and Type: REHAU_RAUTITAN_Bracket E: REHAU_RAUTITAN_Bracket E; Type: REHAU_RAUTITAN_Bracket E; Type Id: 1316422
Constraints - Elevation from Level: 0 mm; Level: REHAU Starting view; Moves With Nearby Elements: no; Offset from Host: 0 mm; Host: Level : REHAU Starting view
Dimensions - a: 188 mm; Area: 0.00766579 m2; b: 40 mm; Volume: 0.0000187018 m3
Identity Data - Mark: 88; PID: 11055351008; REH_DESCRIPTION_SHORT: REHAU Halter E, für Einzelanschluss; REH_GTIN: 4007360629403; REH_NETWEIGHT_G/PC: 184; REH_SUPPLIER_PID: 11055351008
Phasing - Phase Created: New Construction

# IfcBuildingElementProxy: REHAU_RAUTITAN_Bracket O 100:REHAU_RAUTITAN_Bracket O 100, Halter O 100
In: REHAU Starting view
Type - Material: Steel, Galvanized
Type - Other - Category: Mechanical Equipment; Family Name: REHAU_RAUTITAN_Bracket O 100
Type - Constraints - Default Elevation: 0 mm
Type - Data - ETIM_Material mounting profile: Steel; ETIM_Model: Double bridge; ETIM_Number of wall plate locations: 2; ETIM_Surface protection: Hot-dip galvanized
Type - Identity Data - REH_DESCRIPTION_LANGUAGE: Language : EN; Classification Number: 23.27.43.13; ETIM_CLASS: EC010108; ETIM_MODELLING_CLASS: N/A; Manufacturer: REHAU; REH_BIM_SUPPORT: bim@rehau.com; REH_INFO: 2022.10.27-416508-416508; REH_PRICE_LIST: DE_2022; REH_PRODUCT_PICTURE: https://static.rehau.com/bim/images/1000/jpg/M-13584824.jpg; Type Name: REHAU_RAUTITAN_Bracket O 100; URL: www.rehau.com
Type - Pset_ManufacturerTypeInformation - Manufacturer: REHAU
Description: REHAU Bracket O 100, for double connection
Pset_BuildingElementProxyCommon - IsExternal: no; Reference: REHAU_RAUTITAN_Bracket O 100:REHAU_RAUTITAN_Bracket O 100
Pset_EnvironmentalImpactIndicators - Reference: REHAU_RAUTITAN_Bracket O 100:REHAU_RAUTITAN_Bracket O 100
Other - Family: REHAU_RAUTITAN_Bracket O 100; Family and Type: REHAU_RAUTITAN_Bracket O 100: REHAU_RAUTITAN_Bracket O 100; Type: REHAU_RAUTITAN_Bracket O 100; Type Id: 1321558
Constraints - Elevation from Level: 0 mm; Level: REHAU Starting view; Moves With Nearby Elements: no; Offset from Host: 0 mm; Host: Level : REHAU Starting view
Dimensions - a: 396 mm; Area: 0.0187882 m2; b: 40 mm; c: 30 mm; d: 100 mm; Volume: 0.0000487128 m3
Identity Data - Mark: 69; PID: 11055311008; REH_DESCRIPTION_SHORT: REHAU Bracket O 100, for double connection; REH_GTIN: 4007360628567; REH_NETWEIGHT_G/PC: 381; REH_SUPPLIER_PID: 11055311008
Phasing - Phase Created: New Construction

# IfcBuildingElementProxy: REHAU_RAUTITAN_Bracket O 75 150:REHAU_RAUTITAN_Bracket O 75 150, Halter O 75/150
In: REHAU Starting view
Type - Material: Steel, Galvanized
Type - Other - Category: Mechanical Equipment; Family Name: REHAU_RAUTITAN_Bracket O 75 150
Type - Constraints - Default Elevation: 0 mm
Type - Data - ETIM_Number of wall plate locations: 2; ETIM_Material mounting profile: Steel; ETIM_Model: Double bridge; ETIM_Surface protection: Hot-dip galvanized
Type - Identity Data - REH_DESCRIPTION_LANGUAGE: Language : EN; Classification Number: 23.27.43.13; ETIM_CLASS: EC010108; ETIM_MODELLING_CLASS: N/A; Manufacturer: REHAU; REH_BIM_SUPPORT: bim@rehau.com; REH_INFO: 2022.10.27-416508-416508; REH_PRICE_LIST: DE_2022; REH_PRODUCT_PICTURE: https://static.rehau.com/bim/images/1000/jpg/M-53216851.jpg; Type Name: REHAU_RAUTITAN_Bracket O 75 150; URL: www.rehau.com
Type - Pset_ManufacturerTypeInformation - Manufacturer: REHAU
Description: REHAU Bracket O 75/150, for double connection
Pset_BuildingElementProxyCommon - IsExternal: no; Reference: REHAU_RAUTITAN_Bracket O 75 150:REHAU_RAUTITAN_Bracket O 75 150
Pset_EnvironmentalImpactIndicators - Reference: REHAU_RAUTITAN_Bracket O 75 150:REHAU_RAUTITAN_Bracket O 75 150
Other - Family: REHAU_RAUTITAN_Bracket O 75 150; Family and Type: REHAU_RAUTITAN_Bracket O 75 150: REHAU_RAUTITAN_Bracket O 75 150; Type: REHAU_RAUTITAN_Bracket O 75 150; Type Id: 1319016
Constraints - Elevation from Level: 0 mm; Level: REHAU Starting view; Moves With Nearby Elements: no; Offset from Host: 0 mm; Host: Level : REHAU Starting view
Dimensions - a: 446 mm; Area: 0.0207449 m2; b: 40 mm; c: 30 mm; d: 75 mm; e: 150 mm; Volume: 0.0000529963 m3
Identity Data - Mark: 85; PID: 11055291008; REH_DESCRIPTION_SHORT: REHAU Bracket O 75/150, for double connection; REH_GTIN: 4007360628550; REH_NETWEIGHT_G/PC: 411; REH_SUPPLIER_PID: 11055291008
Phasing - Phase Created: New Construction

# IfcBuildingElementProxy: REHAU_RAUTITAN_Bracket UA:REHAU_RAUTITAN_Bracket UA, REHAU_RAUTITAN_Bracket UA:REHAU_RAUTITAN_Bracket UA:1447688
In: REHAU Starting view
Type - Material: <Unnamed>
Type - Other - Category: Generic Models; Family Name: REHAU_RAUTITAN_Bracket UA
Type - Constraints - Default Elevation: 0 mm
Type - Identity Data - REH_DESCRIPTION_LANGUAGE: Language : DE; REH_BIM_SUPPORT: bim@rehau.com; REH_GTIN: 4007360629427; REH_NETWEIGHT_G/PC: 109; REH_PRODUCT_PICTURE: https://static.rehau.com/bim/images/1000/jpg/M-13585488.jpg; Type Name: REHAU_RAUTITAN_Bracket UA
Type - Materials and Finishes - REH_MATERIAL: Steel, Galvanized
Pset_BuildingElementProxyCommon - IsExternal: no; Reference: REHAU_RAUTITAN_Bracket UA:REHAU_RAUTITAN_Bracket UA
Pset_EnvironmentalImpactIndicators - Reference: REHAU_RAUTITAN_Bracket UA:REHAU_RAUTITAN_Bracket UA
Other - Family: REHAU_RAUTITAN_Bracket UA; Family and Type: REHAU_RAUTITAN_Bracket UA: REHAU_RAUTITAN_Bracket UA; Type: REHAU_RAUTITAN_Bracket UA; Type Id: 1326145
Constraints - Elevation from Level: 0 mm; Level: REHAU Starting view; Moves With Nearby Elements: no; Offset from Host: 0 mm; Host: Level : REHAU Starting view
Dimensions - a: 203 mm; Area: 0.00565993 m2; b: 40 mm; Volume: 0.0000136771 m3
Identity Data - ETIM_CLASS: N/A; ETIM_MODELLING_CLASS: N/A; PID: 11055371008; REH_DESCRIPTION_SHORT: Schiebehülse; REH_INFO: 2023.09.18-419114-419114; REH_PRICE_LIST: DE_2023; REH_SUPPLIER_PID: 11055371008
Phasing - Phase Created: New Construction

# IfcBuildingElementProxy: REHAU_RAUTITAN_Bracket Z:REHAU Bracket Z 30, for single connection, Halter Z
In: REHAU Starting view
Type - Material: <Unnamed>
Type - Other - Category: Mechanical Equipment; Family Name: REHAU_RAUTITAN_Bracket Z
Type - Constraints - Default Elevation: 0 mm
Type - Data - ETIM_Number of wall plate locations: 1; ETIM_Material mounting profile: Steel; ETIM_Model: Single; ETIM_Surface protection: Hot-dip galvanized
Type - Identity Data - REH_DESCRIPTION_LANGUAGE: Language : EN; Classification Number: 23.27.43.13; ETIM_CLASS: EC010108; ETIM_MODELLING_CLASS: N/A; Manufacturer: REHAU; REH_BIM_SUPPORT: bim@rehau.com; REH_INFO: 2023.03.10-416508-416508; REH_PRICE_LIST: DE_2022; REH_PRODUCT_PICTURE: https://static.rehau.com/bim/images/1000/jpg/M-53216930.jpg; Type Name: REHAU Bracket Z 30, for single connection; URL: www.rehau.com
Type - Pset_ManufacturerTypeInformation - Manufacturer: REHAU
Description: REHAU Bracket Z 30, for single connection
Pset_BuildingElementProxyCommon - IsExternal: no; Reference: REHAU_RAUTITAN_Bracket Z:REHAU Bracket Z 30, for single connection
Pset_EnvironmentalImpactIndicators - Reference: REHAU_RAUTITAN_Bracket Z:REHAU Bracket Z 30, for single connection
Other - Family: REHAU_RAUTITAN_Bracket Z; Family and Type: REHAU_RAUTITAN_Bracket Z: REHAU Bracket Z 30, for single connection; Type: REHAU Bracket Z 30, for single connection; Type Id: 1328556
Constraints - Elevation from Level: 0 mm; Level: REHAU Starting view; Moves With Nearby Elements: no; Offset from Host: 0 mm; Host: Level : REHAU Starting view
Dimensions - a: 175 mm; Area: 0.00850344 m2; b: 40 mm; c: 30 mm; Volume: 0.0000219751 m3
Identity Data - REH_NETWEIGHT_G/PC: 171; Mark: 89; PID: 11055321008; REH_DESCRIPTION_SHORT: REHAU Bracket Z 30, for single connection; REH_GTIN: 4007360628574; REH_SUPPLIER_PID: 11055321008
Phasing - Phase Created: New Construction

# IfcBuildingElementProxy: REHAU_RAUTITAN_Insulation plate for brackets:REHAU_RAUTITAN_Insulation plate for brackets (11)
In: REHAU Starting view
Type - Material: Black, <Unnamed>
Type - Other - Category: Mechanical Equipment; Family Name: REHAU_RAUTITAN_Insulation plate for brackets
Type - Constraints - Default Elevation: 0 mm
Type - Data - ETIM_Colour: Black; ETIM_Sound-absorbing: yes; ETIM_Suitable for type of connection: Single; ETIM_Thermal insulation: no
Type - Identity Data - Classification Number: 23.75.00.00; ETIM_CLASS: EC010374; ETIM_MODELLING_CLASS: N/A; Manufacturer: REHAU; REH_BIM_SUPPORT: bim@rehau.com; REH_INFO: 2022.10.27-416508-416508; REH_PRICE_LIST: DE_2022; REH_PRODUCT_PICTURE: https://static.rehau.com/bim/images/1000/jpg/M-53217458.jpg; Type Name: REHAU_RAUTITAN_Insulation plate for brackets; URL: www.rehau.com
Type - Pset_ManufacturerTypeInformation - Manufacturer: REHAU
Pset_BuildingElementProxyCommon - IsExternal: no; Reference: REHAU_RAUTITAN_Insulation plate for brackets:REHAU_RAUTITAN_Insulation plate for brackets
Pset_EnvironmentalImpactIndicators - Reference: REHAU_RAUTITAN_Insulation plate for brackets:REHAU_RAUTITAN_Insulation plate for brackets
Other - Family: REHAU_RAUTITAN_Insulation plate for brackets; Family and Type: REHAU_RAUTITAN_Insulation plate for brackets: REHAU_RAUTITAN_Insulation plate for brackets; Type: REHAU_RAUTITAN_Insulation plate for brackets; Type Id: 1311243
Constraints - Level: REHAU Starting view; Moves With Nearby Elements: no; Host: Level : REHAU Starting view
Dimensions - a: 45 mm; Area: 0.00230833 m2; b: 2 mm; c: 1 mm; Volume: 0.00000316699 m3
Identity Data - REH_DESCRIPTION_LANGUAGE: Language : EN; PID: 13207361008; REH_DESCRIPTION_SHORT: REHAU Insulating plate for bracket, incl. two screws M5; REH_GTIN: 4007360629441; REH_NETWEIGHT_G/PC: 7; REH_SUPPLIER_PID: 13207361008
Phasing - Phase Created: New Construction
Name (REHAU_RAUTITAN_Insulation plate for brackets:REHAU_RAUTITAN_Insulation plate for brackets:...) | Elevation from Level (mm) = Offset from Host (mm) | Mark
1444894 | 0 | 76
1444895 | 0 | 77
1447676 | 0 | 90
1447677 | 0 | 91
1447681 | 0 | 92
1447682 | 0 | 93
1447684 | -58.0002 | 94
1447685 | -58.0002 | 95
1447687 | 0 | 96
1447689 | 0 | 97
1447691 | 0 | 98

# IfcBuildingElementProxy: REHAU_RAUTITAN_assembly rail:REHAU_RAUTITAN_assembly rail, REHAU_RAUTITAN_assembly rail:REHAU_RAUTITAN_assembly rail:1447679
In: REHAU Starting view
Type - Material: Steel, Galvanized
Type - Other - Category: Generic Models; Family Name: REHAU_RAUTITAN_assembly rail
Type - Constraints - Default Elevation: 0 mm
Type - Identity Data - Manufacturer: REHAU; REH_BIM_SUPPORT: bim@rehau.com; REH_INFO: 2023.09.18-419114-419114; REH_NETWEIGHT_KG/PC: 1.45; REH_PRODUCT_PICTURE: https://static.rehau.com/bim/images/1000/jpg/M-5192.jpg; Type Name: REHAU_RAUTITAN_assembly rail; URL: www.rehau.com
Type - Materials and Finishes - REH_MATERIAL: Steel, Galvanized
Type - Pset_ManufacturerTypeInformation - Manufacturer: REHAU
Pset_BuildingElementProxyCommon - IsExternal: no; Reference: REHAU_RAUTITAN_assembly rail:REHAU_RAUTITAN_assembly rail
Pset_EnvironmentalImpactIndicators - Reference: REHAU_RAUTITAN_assembly rail:REHAU_RAUTITAN_assembly rail
Other - Family: REHAU_RAUTITAN_assembly rail; Family and Type: REHAU_RAUTITAN_assembly rail: REHAU_RAUTITAN_assembly rail; Type: REHAU_RAUTITAN_assembly rail; Type Id: 1308765
Constraints - Elevation from Level: 0 mm; Level: REHAU Starting view; Moves With Nearby Elements: no; Offset from Host: 0 mm; Host: Level : REHAU Starting view
Dimensions - a: 2005 mm; Area: 0.0825674 m2; b: 40 mm; c: 75 mm; Volume: 0.000193389 m3
Identity Data - ETIM_CLASS: EC010108; ETIM_MODELLING_CLASS: N/A; PID: 11056231008; REH_DESCRIPTION_LANGUAGE: Language : DE; REH_DESCRIPTION_SHORT: REHAU Montageschiene Länge 2 m; REH_GTIN: 4,00736E+12; REH_PRICE_LIST: DE_2023; REH_SUPPLIER_PID: 11056231008
Phasing - Phase Created: New Construction

# IfcBuildingElementProxy: WM Corner Ins. Box Half Inch:WM Ins. Box Half inch (4)
In: REHAU Starting view
Type - Material: PX
Type - Other - Category: Generic Models; Family Name: WM Corner Ins. Box Half Inch; T1: WM Ins. Box Half Inch; Wallmount Ins. Box 1/2: yes
Type - Constraints - Default Elevation: 0 mm
Type - Data - Language: Description en; Language Tender Text: Tender Text en; PID Check: 1 mm; Region Check: Check DE; Region PID: PID DE; Region URL: Product URL DE
Type - Identity Data - Classification Number: 23.60.30.11.14; Description: WM Ins. Box Half inch; Manufacturer: REHAU; Model: RAUTITAN, FASTLOC; REHAU Info: 14.02.2024-420668-420668; Type Name: WM Ins. Box Half inch
Type - Materials and Finishes - Mat. Ins. Box: PX
Type - Pset_ManufacturerTypeInformation - Manufacturer: REHAU
Pset_BuildingElementProxyCommon - IsExternal: no; Reference: WM Corner Ins. Box Half Inch:WM Ins. Box Half inch
Pset_EnvironmentalImpactIndicators - Reference: WM Corner Ins. Box Half Inch:WM Ins. Box Half inch
Other - Family: WM Corner Ins. Box Half Inch; Family and Type: WM Corner Ins. Box Half Inch: WM Ins. Box Half inch; Type: WM Ins. Box Half inch; Type Id: 1340659
Constraints - Elevation from Level: 0 mm; Level: REHAU Starting view; Moves With Nearby Elements: no; Offset from Host: 0 mm; Host: Level : REHAU Starting view
Dimensions - Area: 0.0121354 m2; Volume: 0.000129236 m3
Identity Data - Sorting: 0; Description long: REHAU Sound-/thermal-insulation box for wall-mounted elbow Rp 1/2; ETIM Class: EC010374; ETIM Group: EG015540; ETIM Name: Wall plate insulation; GTIN: 4007360451592; PID: 12069271001; Product Group: 1138; Product URL: https://oxomi.com/p/3000126/datasheet/-/12069271001; Tender text: -; Weight: 0.004
Phasing - Phase Created: New Construction
Name (WM Corner Ins. Box Half Inch:WM Ins. Box Half inch:...)
1353995
1354081
1354083
1354085

# IfcDistributionPort (986)
Description: Flow; PredefinedType: PIPE
Name | FlowDirection
Port_884892_1 | SOURCEANDSINK
Port_884892_2 | SOURCEANDSINK
Port_885472_1 | SOURCEANDSINK
Port_885472_2 | SOURCEANDSINK
Port_885485_1 | SOURCEANDSINK
Port_885485_2 | SOURCEANDSINK
Port_885598_1 | SOURCEANDSINK
Port_885598_2 | SOURCEANDSINK
Port_885683_1 | SOURCEANDSINK
Port_885683_2 | SOURCEANDSINK
Port_885698_1 | SOURCEANDSINK
Port_885698_2 | SOURCEANDSINK
Port_885872_1 | SOURCEANDSINK
Port_885872_2 | SOURCEANDSINK
Port_885987_1 | SOURCEANDSINK
Port_885987_2 | SOURCEANDSINK
Port_886085_1 | SOURCEANDSINK
Port_886085_2 | SOURCEANDSINK
Port_905539_4 | SOURCEANDSINK
Port_905539_5 | SOURCEANDSINK
Port_905539_6 | SOURCEANDSINK
Port_905870_4 | SOURCEANDSINK
Port_905870_5 | SOURCEANDSINK
Port_905870_6 | SOURCEANDSINK
Port_906051_4 | SOURCEANDSINK
Port_906051_5 | SOURCEANDSINK
Port_906051_6 | SOURCEANDSINK
Port_907062_4 | SOURCEANDSINK
Port_907062_5 | SOURCEANDSINK
Port_907062_6 | SOURCEANDSINK
Port_931723_4 | SOURCEANDSINK
Port_931723_5 | SOURCEANDSINK
Port_931723_6 | SOURCEANDSINK
Port_931823_4 | SOURCEANDSINK
Port_931823_5 | SOURCEANDSINK
Port_931823_6 | SOURCEANDSINK
Port_931939_4 | SOURCEANDSINK
Port_931939_5 | SOURCEANDSINK
Port_931939_6 | SOURCEANDSINK
Port_932075_4 | SOURCEANDSINK
Port_932075_5 | SOURCEANDSINK
Port_932075_6 | SOURCEANDSINK
Port_932161_4 | SOURCEANDSINK
Port_932161_5 | SOURCEANDSINK
Port_932161_6 | SOURCEANDSINK
Port_932169_4 | SOURCEANDSINK
Port_932169_5 | SOURCEANDSINK
Port_932169_6 | SOURCEANDSINK
Port_932177_4 | SOURCEANDSINK
Port_932177_5 | SOURCEANDSINK
Port_932177_6 | SOURCEANDSINK
Port_932185_4 | SOURCEANDSINK
Port_932185_5 | SOURCEANDSINK
Port_932185_6 | SOURCEANDSINK
Port_932193_4 | SOURCEANDSINK
Port_932193_5 | SOURCEANDSINK
Port_932193_6 | SOURCEANDSINK
Port_932201_4 | SOURCEANDSINK
Port_932201_5 | SOURCEANDSINK
Port_932201_6 | SOURCEANDSINK
Port_932209_4 | SOURCEANDSINK
Port_932209_5 | SOURCEANDSINK
Port_932209_6 | SOURCEANDSINK
Port_932521_4 | SOURCEANDSINK
Port_932521_5 | SOURCEANDSINK
Port_932521_6 | SOURCEANDSINK
Port_932529_4 | SOURCEANDSINK
Port_932529_5 | SOURCEANDSINK
Port_932529_6 | SOURCEANDSINK
Port_932537_4 | SOURCEANDSINK
Port_932537_5 | SOURCEANDSINK
Port_932537_6 | SOURCEANDSINK
Port_932545_4 | SOURCEANDSINK
Port_932545_5 | SOURCEANDSINK
Port_932545_6 | SOURCEANDSINK
Port_932553_4 | SOURCEANDSINK
Port_932553_5 | SOURCEANDSINK
Port_932553_6 | SOURCEANDSINK
Port_932561_4 | SOURCEANDSINK
Port_932561_5 | SOURCEANDSINK
Port_932561_6 | SOURCEANDSINK
Port_943224_4 | SOURCEANDSINK
Port_943224_5 | SOURCEANDSINK
Port_943224_6 | SOURCEANDSINK
Port_943294_4 | SOURCEANDSINK
Port_943294_5 | SOURCEANDSINK
Port_943294_6 | SOURCEANDSINK
Port_943302_4 | SOURCEANDSINK
Port_943302_5 | SOURCEANDSINK
Port_943302_6 | SOURCEANDSINK
Port_943405_4 | SOURCEANDSINK
Port_943405_5 | SOURCEANDSINK
Port_943405_6 | SOURCEANDSINK
Port_943413_4 | SOURCEANDSINK
Port_943413_5 | SOURCEANDSINK
Port_943413_6 | SOURCEANDSINK
Port_943421_4 | SOURCEANDSINK
Port_943421_5 | SOURCEANDSINK
Port_943421_6 | SOURCEANDSINK
Port_943429_4 | SOURCEANDSINK
Port_943429_5 | SOURCEANDSINK
Port_943429_6 | SOURCEANDSINK
Port_943437_4 | SOURCEANDSINK
Port_943437_5 | SOURCEANDSINK
Port_943437_6 | SOURCEANDSINK
Port_943719_4 | SOURCEANDSINK
Port_943719_5 | SOURCEANDSINK
Port_943719_6 | SOURCEANDSINK
Port_943727_4 | SOURCEANDSINK
Port_943727_5 | SOURCEANDSINK
Port_943727_6 | SOURCEANDSINK
Port_943735_4 | SOURCEANDSINK
Port_943735_5 | SOURCEANDSINK
Port_943735_6 | SOURCEANDSINK
Port_943743_4 | SOURCEANDSINK
Port_943743_5 | SOURCEANDSINK
Port_943743_6 | SOURCEANDSINK
Port_943919_4 | SOURCEANDSINK
Port_943919_5 | SOURCEANDSINK
Port_943919_6 | SOURCEANDSINK
Port_944019_4 | SOURCEANDSINK
Port_944019_5 | SOURCEANDSINK
Port_944019_6 | SOURCEANDSINK
Port_944027_4 | SOURCEANDSINK
Port_944027_5 | SOURCEANDSINK
Port_944027_6 | SOURCEANDSINK
Port_944500_1 | SOURCEANDSINK
Port_944500_2 | SOURCEANDSINK
Port_948439_1 | SOURCEANDSINK
Port_948439_2 | SOURCEANDSINK
Port_948555_1 | SOURCEANDSINK
Port_948555_2 | SOURCEANDSINK
Port_948622_1 | SOURCEANDSINK
Port_948622_2 | SOURCEANDSINK
Port_948635_1 | SOURCEANDSINK
Port_948635_2 | SOURCEANDSINK
Port_948740_1 | SOURCEANDSINK
Port_948740_2 | SOURCEANDSINK
Port_948753_1 | SOURCEANDSINK
Port_948753_2 | SOURCEANDSINK
Port_948766_1 | SOURCEANDSINK
Port_948766_2 | SOURCEANDSINK
Port_956633_1 | SOURCEANDSINK
Port_956633_2 | SOURCEANDSINK
Port_957116_1 | SOURCEANDSINK
Port_957116_2 | SOURCEANDSINK
Port_957207_1 | SOURCEANDSINK
Port_957207_2 | SOURCEANDSINK
Port_957302_1 | SOURCEANDSINK
Port_957302_2 | SOURCEANDSINK
Port_957384_1 | SOURCEANDSINK
Port_957384_2 | SOURCEANDSINK
Port_957485_1 | SOURCEANDSINK
Port_957485_2 | SOURCEANDSINK
Port_961596_1 | SOURCEANDSINK
Port_961596_2 | SOURCEANDSINK
Port_961602_1 | SOURCEANDSINK
Port_961602_2 | SOURCEANDSINK
Port_961608_1 | SOURCEANDSINK
Port_961608_2 | SOURCEANDSINK
Port_961614_1 | SOURCEANDSINK
Port_961614_2 | SOURCEANDSINK
Port_961620_1 | SOURCEANDSINK
Port_961620_2 | SOURCEANDSINK
Port_986855_1 | SOURCEANDSINK
Port_986855_2 | SOURCEANDSINK
Port_986868_1 | SOURCEANDSINK
Port_986868_2 | SOURCEANDSINK
Port_986992_1 | SOURCEANDSINK
Port_986992_2 | SOURCEANDSINK
Port_986994_1 | SOURCEANDSINK
Port_986994_2 | SOURCEANDSINK
Port_1007346_4 | SOURCEANDSINK
Port_1007346_5 | SOURCEANDSINK
Port_1007346_6 | SOURCEANDSINK
Port_1007348_4 | SOURCEANDSINK
Port_1007348_5 | SOURCEANDSINK
Port_1007348_6 | SOURCEANDSINK
Port_1007350_4 | SOURCEANDSINK
Port_1007350_5 | SOURCEANDSINK
Port_1007350_6 | SOURCEANDSINK
Port_1007352_4 | SOURCEANDSINK
Port_1007352_5 | SOURCEANDSINK
Port_1007352_6 | SOURCEANDSINK
Port_1007354_4 | SOURCEANDSINK
Port_1007354_5 | SOURCEANDSINK
Port_1007354_6 | SOURCEANDSINK
Port_1007356_4 | SOURCEANDSINK
Port_1007356_5 | SOURCEANDSINK
Port_1007356_6 | SOURCEANDSINK
Port_1007358_4 | SOURCEANDSINK
Port_1007358_5 | SOURCEANDSINK
Port_1007358_6 | SOURCEANDSINK
Port_1007360_4 | SOURCEANDSINK
Port_1007360_5 | SOURCEANDSINK
Port_1007360_6 | SOURCEANDSINK
Port_1007362_4 | SOURCEANDSINK
Port_1007362_5 | SOURCEANDSINK
Port_1007362_6 | SOURCEANDSINK
Port_1007364_4 | SOURCEANDSINK
Port_1007364_5 | SOURCEANDSINK
Port_1007364_6 | SOURCEANDSINK
Port_1007366_4 | SOURCEANDSINK
Port_1007366_5 | SOURCEANDSINK
Port_1007366_6 | SOURCEANDSINK
Port_1007368_4 | SOURCEANDSINK
Port_1007368_5 | SOURCEANDSINK
Port_1007368_6 | SOURCEANDSINK
Port_1007370_4 | SOURCEANDSINK
Port_1007370_5 | SOURCEANDSINK
Port_1007370_6 | SOURCEANDSINK
Port_1007372_4 | SOURCEANDSINK
Port_1007372_5 | SOURCEANDSINK
Port_1007372_6 | SOURCEANDSINK
Port_1007374_4 | SOURCEANDSINK
Port_1007374_5 | SOURCEANDSINK
Port_1007374_6 | SOURCEANDSINK
Port_1007376_4 | SOURCEANDSINK
Port_1007376_5 | SOURCEANDSINK
Port_1007376_6 | SOURCEANDSINK
Port_1007378_4 | SOURCEANDSINK
Port_1007378_5 | SOURCEANDSINK
Port_1007378_6 | SOURCEANDSINK
Port_1007380_4 | SOURCEANDSINK
Port_1007380_5 | SOURCEANDSINK
Port_1007380_6 | SOURCEANDSINK
Port_1007382_4 | SOURCEANDSINK
Port_1007382_5 | SOURCEANDSINK
Port_1007382_6 | SOURCEANDSINK
Port_1007384_4 | SOURCEANDSINK
Port_1007384_5 | SOURCEANDSINK
Port_1007384_6 | SOURCEANDSINK
Port_1007386_4 | SOURCEANDSINK
Port_1007386_5 | SOURCEANDSINK
Port_1007386_6 | SOURCEANDSINK
Port_1007388_4 | SOURCEANDSINK
Port_1007388_5 | SOURCEANDSINK
Port_1007388_6 | SOURCEANDSINK
Port_1007390_4 | SOURCEANDSINK
Port_1007390_5 | SOURCEANDSINK
Port_1007390_6 | SOURCEANDSINK
Port_1007392_4 | SOURCEANDSINK
Port_1007392_5 | SOURCEANDSINK
Port_1007392_6 | SOURCEANDSINK
Port_1007394_4 | SOURCEANDSINK
Port_1007394_5 | SOURCEANDSINK
Port_1007394_6 | SOURCEANDSINK
Port_1007396_4 | SOURCEANDSINK
Port_1007396_5 | SOURCEANDSINK
Port_1007396_6 | SOURCEANDSINK
Port_1007398_4 | SOURCEANDSINK
Port_1007398_5 | SOURCEANDSINK
Port_1007398_6 | SOURCEANDSINK
Port_1007400_4 | SOURCEANDSINK
Port_1007400_5 | SOURCEANDSINK
Port_1007400_6 | SOURCEANDSINK
Port_1007402_4 | SOURCEANDSINK
Port_1007402_5 | SOURCEANDSINK
Port_1007402_6 | SOURCEANDSINK
Port_1007404_4 | SOURCEANDSINK
Port_1007404_5 | SOURCEANDSINK
Port_1007404_6 | SOURCEANDSINK
Port_1007406_4 | SOURCEANDSINK
Port_1007406_5 | SOURCEANDSINK
Port_1007406_6 | SOURCEANDSINK
Port_1007408_4 | SOURCEANDSINK
Port_1007408_5 | SOURCEANDSINK
Port_1007408_6 | SOURCEANDSINK
Port_1007410_4 | SOURCEANDSINK
Port_1007410_5 | SOURCEANDSINK
Port_1007410_6 | SOURCEANDSINK
Port_1007412_4 | SOURCEANDSINK
Port_1007412_5 | SOURCEANDSINK
Port_1007412_6 | SOURCEANDSINK
Port_1007414_4 | SOURCEANDSINK
Port_1007414_5 | SOURCEANDSINK
Port_1007414_6 | SOURCEANDSINK
Port_1007416_4 | SOURCEANDSINK
Port_1007416_5 | SOURCEANDSINK
Port_1007416_6 | SOURCEANDSINK
Port_1078135_1 | SOURCEANDSINK
Port_1078135_2 | SOURCEANDSINK
Port_1078137_1 | SOURCEANDSINK
Port_1078137_2 | SOURCEANDSINK
Port_1078139_1 | SOURCEANDSINK
Port_1078139_2 | SOURCEANDSINK
Port_1078141_1 | SOURCEANDSINK
Port_1078141_2 | SOURCEANDSINK
Port_1078143_1 | SOURCEANDSINK
Port_1078143_2 | SOURCEANDSINK
Port_1078145_1 | SOURCEANDSINK
Port_1078145_2 | SOURCEANDSINK
Port_1078147_1 | SOURCEANDSINK
Port_1078147_2 | SOURCEANDSINK
Port_1078149_1 | SOURCEANDSINK
Port_1078149_2 | SOURCEANDSINK
Port_1078151_1 | SOURCEANDSINK
Port_1078151_2 | SOURCEANDSINK
Port_1078154_1 | SOURCEANDSINK
Port_1078154_2 | SOURCEANDSINK
Port_1078158_1 | SOURCEANDSINK
Port_1078158_2 | SOURCEANDSINK
Port_1078163_1 | SOURCEANDSINK
Port_1078163_3 | SOURCEANDSINK
Port_1078163_4 | SOURCEANDSINK
Port_1078165_1 | SOURCEANDSINK
Port_1078165_3 | SOURCEANDSINK
Port_1078165_4 | SOURCEANDSINK
Port_1078167_1 | SOURCEANDSINK
Port_1078167_3 | SOURCEANDSINK
Port_1078167_4 | SOURCEANDSINK
Port_1078169_1 | SOURCEANDSINK
Port_1078169_3 | SOURCEANDSINK
Port_1078169_4 | SOURCEANDSINK
Port_1078171_1 | SOURCEANDSINK
Port_1078171_3 | SOURCEANDSINK
Port_1078171_4 | SOURCEANDSINK
Port_1078181_1 | SOURCEANDSINK
Port_1078181_3 | SOURCEANDSINK
Port_1078181_4 | SOURCEANDSINK
Port_1078183_1 | SOURCEANDSINK
Port_1078183_3 | SOURCEANDSINK
Port_1078183_4 | SOURCEANDSINK
Port_1078186_1 | SOURCEANDSINK
Port_1078186_3 | SOURCEANDSINK
Port_1078186_4 | SOURCEANDSINK
Port_1078188_1 | SOURCEANDSINK
Port_1078188_3 | SOURCEANDSINK
Port_1078188_4 | SOURCEANDSINK
Port_1078190_1 | SOURCEANDSINK
Port_1078190_3 | SOURCEANDSINK
Port_1078190_4 | SOURCEANDSINK
Port_1078192_1 | SOURCEANDSINK
Port_1078192_3 | SOURCEANDSINK
Port_1078192_4 | SOURCEANDSINK
Port_1078194_1 | SOURCEANDSINK
Port_1078194_3 | SOURCEANDSINK
Port_1078194_4 | SOURCEANDSINK
Port_1078196_1 | SOURCEANDSINK
Port_1078196_3 | SOURCEANDSINK
Port_1078196_4 | SOURCEANDSINK
Port_1078199_1 | SOURCEANDSINK
Port_1078199_3 | SOURCEANDSINK
Port_1078199_4 | SOURCEANDSINK
Port_1078201_1 | SOURCEANDSINK
Port_1078201_3 | SOURCEANDSINK
Port_1078201_4 | SOURCEANDSINK
Port_1078203_1 | SOURCEANDSINK
Port_1078203_3 | SOURCEANDSINK
Port_1078203_4 | SOURCEANDSINK
Port_1078205_1 | SOURCEANDSINK
Port_1078205_3 | SOURCEANDSINK
Port_1078205_4 | SOURCEANDSINK
Port_1078207_1 | SOURCEANDSINK
Port_1078207_3 | SOURCEANDSINK
Port_1078207_4 | SOURCEANDSINK
Port_1078210_1 | SOURCEANDSINK
Port_1078210_3 | SOURCEANDSINK
Port_1078210_4 | SOURCEANDSINK
Port_1078212_1 | SOURCEANDSINK
Port_1078212_3 | SOURCEANDSINK
Port_1078212_4 | SOURCEANDSINK
Port_1078214_1 | SOURCEANDSINK
Port_1078214_3 | SOURCEANDSINK
Port_1078214_4 | SOURCEANDSINK
Port_1078216_1 | SOURCEANDSINK
Port_1078216_3 | SOURCEANDSINK
Port_1078216_4 | SOURCEANDSINK
Port_1078218_1 | SOURCEANDSINK
Port_1078218_3 | SOURCEANDSINK
Port_1078218_4 | SOURCEANDSINK
Port_1078220_1 | SOURCEANDSINK
Port_1078220_3 | SOURCEANDSINK
Port_1078220_4 | SOURCEANDSINK
Port_1078222_1 | SOURCEANDSINK
Port_1078222_3 | SOURCEANDSINK
Port_1078222_4 | SOURCEANDSINK
Port_1078225_1 | SOURCEANDSINK
Port_1078225_3 | SOURCEANDSINK
Port_1078225_4 | SOURCEANDSINK
Port_1078227_1 | SOURCEANDSINK
Port_1078227_3 | SOURCEANDSINK
Port_1078227_4 | SOURCEANDSINK
Port_1078229_1 | SOURCEANDSINK
Port_1078229_3 | SOURCEANDSINK
Port_1078229_4 | SOURCEANDSINK
Port_1078231_1 | SOURCEANDSINK
Port_1078231_3 | SOURCEANDSINK
Port_1078231_4 | SOURCEANDSINK
Port_1078233_1 | SOURCEANDSINK
Port_1078233_3 | SOURCEANDSINK
Port_1078233_4 | SOURCEANDSINK
Port_1078235_1 | SOURCEANDSINK
Port_1078235_3 | SOURCEANDSINK
Port_1078235_4 | SOURCEANDSINK
Port_1078238_1 | SOURCEANDSINK
Port_1078238_3 | SOURCEANDSINK
Port_1078238_4 | SOURCEANDSINK
Port_1078240_1 | SOURCEANDSINK
Port_1078240_3 | SOURCEANDSINK
Port_1078240_4 | SOURCEANDSINK
Port_1078243_1 | SOURCEANDSINK
Port_1078243_3 | SOURCEANDSINK
Port_1078243_4 | SOURCEANDSINK
Port_1078245_1 | SOURCEANDSINK
Port_1078245_3 | SOURCEANDSINK
Port_1078245_4 | SOURCEANDSINK
Port_1078247_1 | SOURCEANDSINK
Port_1078247_3 | SOURCEANDSINK
Port_1078247_4 | SOURCEANDSINK
Port_1078250_1 | SOURCEANDSINK
Port_1078250_3 | SOURCEANDSINK
Port_1078250_4 | SOURCEANDSINK
Port_1078252_1 | SOURCEANDSINK
Port_1078252_3 | SOURCEANDSINK
Port_1078252_4 | SOURCEANDSINK
Port_1078255_1 | SOURCEANDSINK
Port_1078255_3 | SOURCEANDSINK
Port_1078255_4 | SOURCEANDSINK
Port_1078257_1 | SOURCEANDSINK
Port_1078257_3 | SOURCEANDSINK
Port_1078257_4 | SOURCEANDSINK
Port_1078259_1 | SOURCEANDSINK
Port_1078259_3 | SOURCEANDSINK
Port_1078259_4 | SOURCEANDSINK
Port_1078262_1 | SOURCEANDSINK
Port_1078262_3 | SOURCEANDSINK
Port_1078262_4 | SOURCEANDSINK
Port_1078264_1 | SOURCEANDSINK
Port_1078264_3 | SOURCEANDSINK
Port_1078264_4 | SOURCEANDSINK
Port_1078266_1 | SOURCEANDSINK
Port_1078266_3 | SOURCEANDSINK
Port_1078266_4 | SOURCEANDSINK
Port_1078268_1 | SOURCEANDSINK
Port_1078268_2 | SOURCEANDSINK
Port_1078270_1 | SOURCEANDSINK
Port_1078270_2 | SOURCEANDSINK
Port_1078272_1 | SOURCEANDSINK
Port_1078272_2 | SOURCEANDSINK
Port_1078274_1 | SOURCEANDSINK
Port_1078274_2 | SOURCEANDSINK
Port_1078276_1 | SOURCEANDSINK
Port_1078276_2 | SOURCEANDSINK
Port_1078278_1 | SOURCEANDSINK
Port_1078278_2 | SOURCEANDSINK
Port_1078280_1 | SOURCEANDSINK
Port_1078280_2 | SOURCEANDSINK
Port_1078284_1 | SOURCEANDSINK
Port_1078284_2 | SOURCEANDSINK
Port_1078286_1 | SOURCEANDSINK
Port_1078286_2 | SOURCEANDSINK
Port_1078288_1 | SOURCEANDSINK
Port_1078288_2 | SOURCEANDSINK
Port_1078290_1 | SOURCEANDSINK
Port_1078290_2 | SOURCEANDSINK
Port_1078292_1 | SOURCEANDSINK
Port_1078292_2 | SOURCEANDSINK
Port_1078294_1 | SOURCEANDSINK
Port_1078294_2 | SOURCEANDSINK
Port_1078297_1 | SOURCEANDSINK
Port_1078297_2 | SOURCEANDSINK
Port_1078299_1 | SOURCEANDSINK
Port_1078299_2 | SOURCEANDSINK
Port_1078301_1 | SOURCEANDSINK
Port_1078301_2 | SOURCEANDSINK
Port_1078303_1 | SOURCEANDSINK
Port_1078303_2 | SOURCEANDSINK
Port_1078305_1 | SOURCEANDSINK
Port_1078305_2 | SOURCEANDSINK
Port_1078307_1 | SOURCEANDSINK
Port_1078307_2 | SOURCEANDSINK
Port_1078309_1 | SOURCEANDSINK
Port_1078309_2 | SOURCEANDSINK
Port_1078312_1 | SOURCEANDSINK
Port_1078312_2 | SOURCEANDSINK
Port_1078314_1 | SOURCEANDSINK
Port_1078314_2 | SOURCEANDSINK
Port_1078316_1 | SOURCEANDSINK
Port_1078316_2 | SOURCEANDSINK
Port_1078318_1 | SOURCEANDSINK
Port_1078318_2 | SOURCEANDSINK
Port_1078320_1 | SOURCEANDSINK
Port_1078320_2 | SOURCEANDSINK
Port_1078322_1 | SOURCEANDSINK
Port_1078322_2 | SOURCEANDSINK
Port_1078349_1 | SOURCEANDSINK
Port_1078349_2 | SOURCEANDSINK
Port_1078351_1 | SOURCEANDSINK
Port_1078351_2 | SOURCEANDSINK
Port_1078356_1 | SOURCEANDSINK
Port_1078356_3 | SOURCEANDSINK
Port_1078356_4 | SOURCEANDSINK
Port_1078358_1 | SOURCEANDSINK
Port_1078358_3 | SOURCEANDSINK
Port_1078358_4 | SOURCEANDSINK
Port_1078360_1 | SOURCEANDSINK
Port_1078360_3 | SOURCEANDSINK
Port_1078360_4 | SOURCEANDSINK
Port_1078370_1 | SOURCEANDSINK
Port_1078370_3 | SOURCEANDSINK
Port_1078370_4 | SOURCEANDSINK
Port_1078372_1 | SOURCEANDSINK
Port_1078372_3 | SOURCEANDSINK
Port_1078372_4 | SOURCEANDSINK
Port_1078377_1 | SOURCEANDSINK
Port_1078377_3 | SOURCEANDSINK
Port_1078377_4 | SOURCEANDSINK
Port_1078379_1 | SOURCEANDSINK
Port_1078379_3 | SOURCEANDSINK
Port_1078379_4 | SOURCEANDSINK
Port_1078381_1 | SOURCEANDSINK
Port_1078381_3 | SOURCEANDSINK
Port_1078381_4 | SOURCEANDSINK
Port_1078383_1 | SOURCEANDSINK
Port_1078383_3 | SOURCEANDSINK
Port_1078383_4 | SOURCEANDSINK
Port_1078386_1 | SOURCEANDSINK
Port_1078386_3 | SOURCEANDSINK
Port_1078386_4 | SOURCEANDSINK
Port_1078388_1 | SOURCEANDSINK
Port_1078388_3 | SOURCEANDSINK
Port_1078388_4 | SOURCEANDSINK
Port_1078390_1 | SOURCEANDSINK
Port_1078390_3 | SOURCEANDSINK
Port_1078390_4 | SOURCEANDSINK
Port_1078393_1 | SOURCEANDSINK
Port_1078393_3 | SOURCEANDSINK
Port_1078393_4 | SOURCEANDSINK
Port_1078395_1 | SOURCEANDSINK
Port_1078395_3 | SOURCEANDSINK
Port_1078395_4 | SOURCEANDSINK
Port_1078398_1 | SOURCEANDSINK
Port_1078398_3 | SOURCEANDSINK
Port_1078398_4 | SOURCEANDSINK
Port_1078400_1 | SOURCEANDSINK
Port_1078400_3 | SOURCEANDSINK
Port_1078400_4 | SOURCEANDSINK
Port_1078403_1 | SOURCEANDSINK
Port_1078403_3 | SOURCEANDSINK
Port_1078403_4 | SOURCEANDSINK
Port_1078405_1 | SOURCEANDSINK
Port_1078405_3 | SOURCEANDSINK
Port_1078405_4 | SOURCEANDSINK
Port_1078407_1 | SOURCEANDSINK
Port_1078407_3 | SOURCEANDSINK
Port_1078407_4 | SOURCEANDSINK
Port_1078409_1 | SOURCEANDSINK
Port_1078409_2 | SOURCEANDSINK
Port_1078411_1 | SOURCEANDSINK
Port_1078411_2 | SOURCEANDSINK
Port_1078413_1 | SOURCEANDSINK
Port_1078413_2 | SOURCEANDSINK
Port_1078415_1 | SOURCEANDSINK
Port_1078415_2 | SOURCEANDSINK
Port_1078417_1 | SOURCEANDSINK
Port_1078417_2 | SOURCEANDSINK
Port_1078419_1 | SOURCEANDSINK
Port_1078419_2 | SOURCEANDSINK
Port_1078423_1 | SOURCEANDSINK
Port_1078423_2 | SOURCEANDSINK
Port_1078425_1 | SOURCEANDSINK
Port_1078425_2 | SOURCEANDSINK
Port_1078428_1 | SOURCEANDSINK
Port_1078428_2 | SOURCEANDSINK
Port_1078430_1 | SOURCEANDSINK
Port_1078430_2 | SOURCEANDSINK
Port_1078432_1 | SOURCEANDSINK
Port_1078432_2 | SOURCEANDSINK
Port_1078434_1 | SOURCEANDSINK
Port_1078434_2 | SOURCEANDSINK
Port_1078436_1 | SOURCEANDSINK
Port_1078436_2 | SOURCEANDSINK
Port_1078439_1 | SOURCEANDSINK
Port_1078439_2 | SOURCEANDSINK
Port_1078441_1 | SOURCEANDSINK
Port_1078441_2 | SOURCEANDSINK
Port_1078443_1 | SOURCEANDSINK
Port_1078443_2 | SOURCEANDSINK
Port_1078445_1 | SOURCEANDSINK
Port_1078445_2 | SOURCEANDSINK
Port_1078447_1 | SOURCEANDSINK
Port_1078447_2 | SOURCEANDSINK
Port_1078458_1 | SOURCEANDSINK
Port_1078458_2 | SOURCEANDSINK
Port_1078561_1 | SOURCEANDSINK
Port_1078561_2 | SOURCEANDSINK
Port_1078565_1 | SOURCEANDSINK
Port_1078565_2 | SOURCEANDSINK
Port_1078963_1 | SOURCEANDSINK
Port_1078963_2 | SOURCEANDSINK
Port_1078965_1 | SOURCEANDSINK
Port_1078965_2 | SOURCEANDSINK
Port_1079111_1 | SOURCEANDSINK
Port_1079111_2 | SOURCEANDSINK
Port_1079124_1 | SOURCEANDSINK
Port_1079124_2 | SOURCEANDSINK
InPort_1087087_1 | SINK | SystemType: DOMESTICCOLDWATER
InPort_1087090_1 | SINK | SystemType: DOMESTICCOLDWATER
InPort_1087093_1 | SINK | SystemType: DOMESTICCOLDWATER
InPort_1087096_1 | SINK | SystemType: DOMESTICCOLDWATER
InPort_1087099_1 | SINK | SystemType: DOMESTICCOLDWATER
InPort_1087102_1 | SINK | SystemType: DOMESTICCOLDWATER
InPort_1087105_1 | SINK | SystemType: DOMESTICCOLDWATER
InPort_1087108_1 | SINK | SystemType: DOMESTICCOLDWATER
InPort_1087111_1 | SINK | SystemType: DOMESTICCOLDWATER
InPort_1087114_1 | SINK | SystemType: DOMESTICCOLDWATER
