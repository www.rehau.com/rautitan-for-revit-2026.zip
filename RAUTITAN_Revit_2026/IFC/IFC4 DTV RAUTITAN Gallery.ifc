Properties of the parts of a building model (IFC4), part 10 of 10

# IfcPipeSegment: Pipe Types:RAUTITAN Stabil PX & RX+ Stabil Do (7)
Name (Pipe Types:RAUTITAN Stabil PX & RX+ Stabil Do:...) | InvertElevation (mm) = Lower End Invert Elevation (mm) = Upper End Invert Elevation (mm) = Invert Elevation (mm) | Lower End Bottom Elevation (mm) = Upper End Bottom Elevation (mm) = Lower End Bottom of Insulation Elevation (mm) = Upper End Bottom of Insulation Elevation (mm) | Lower End Obvert Elevation (mm) = Upper End Obvert Elevation (mm) | Lower End Top Elevation (mm) = Upper End Top Elevation (mm) = Lower End Top of Insulation Elevation (mm) = Upper End Top of Insulation Elevation (mm) | Inside Diameter (mm) | Outside Diameter (mm) | Size = Overall Size | Wall Thickness (mm) | Area (m2) | Diameter (mm) | System Name = Group | Relative Roughness
1151189 | -8.8 | -12.5 | 8.8 | 12.5 | 17.6 | 25 | 25 mmø | 3.7 | 0.0785398 | 25 | Domestic Cold Water 47 | 0.000397727
1151191 | -11.3 | -16 | 11.3 | 16 | 22.6 | 32 | 32 mmø | 4.7 | 0.100531 | 32 | Domestic Cold Water 48 | 0.000309735
1151193 | -14 | -20 | 14 | 20 | 28 | 40 | 40 mmø | 6 | 0.125664 | 40 | Domestic Cold Water 49 | 0.00025
1151195 | -20.5 | -25 | 20.5 | 25 | 41 | 50 | 50 mmø | 4.5 | 0.15708 | 50 | Domestic Cold Water 50 | 0.000170732
1151197 | -25.5 | -31.5 | 25.5 | 31.5 | 51 | 63 | 63 mmø | 6 | 0.19792 | 63 | Domestic Cold Water 51 | 0.000137255

# IfcPipeSegment: Pipe Types:RAUTITAN flex LX & RX+ DN (8)
In: REHAU Starting view
Type - Other - Category: Pipes; Family Name: Pipe Types
Type - Identity Data - Assembly Code: 11303701100, 11303801100, 11303901050, 11304001050, 11304101006; Description: Drinking water & heating; Manufacturer: REHAU; Model: RAUTITAN; Type Comments: DN 12-32; Type Name: RAUTITAN flex LX & RX+ DN; URL: www.rehau.com
Type - Pset_ManufacturerTypeInformation - Manufacturer: REHAU
Classification: 11303701100, 11303801100, 11303901050, 11304001050, 11304101006 (Uniformat)
Pset_EnvironmentalImpactIndicators - Reference: Pipe Types:RAUTITAN flex LX & RX+ DN; sets with these values: 2
Other - Family: Pipe Types; Family and Type: Pipe Types: RAUTITAN flex LX & RX+ DN; Type: RAUTITAN flex LX & RX+ DN; Type Id: 847740
Constraints - End Middle Elevation: 0 mm; Horizontal Justification: Center; Lower End Centerline Elevation: 0 mm; Middle Elevation: 0 mm; Reference Level: REHAU Starting view; Slope: 0; Start Middle Elevation: 0 mm; Upper End Centerline Elevation: 0 mm; Vertical Justification: Middle
Dimensions - Length: 1000 mm
Mechanical - System Type: Domestic Cold Water; Connection Type: Generic; Material: RAUTITAN flex; Pipe Segment: RAUTITAN flex - 10 - 50; Roughness: 0.007 mm; Schedule/Type: 10 - 50; System Classification: Domestic Cold Water
Mechanical - Flow - Additional Flow: 0 dm3/s; Fixture Units: 0; Flow: 0 dm3/s; Flow State: Laminar; Friction Factor: 0; Pressure Drop: 0 Pa; Reynolds Number: 0; Section: 1; Velocity: 0 m/s; Velocity Pressure: 0 Pa; Friction: 0 kg/m2/s2
Phasing - Phase Created: New Construction
Insulation - Insulation Thickness: 0 mm
Name (Pipe Types:RAUTITAN flex LX & RX+ DN:...) | InvertElevation (mm) = Lower End Invert Elevation (mm) = Upper End Invert Elevation (mm) = Invert Elevation (mm) | Lower End Bottom Elevation (mm) = Upper End Bottom Elevation (mm) = Lower End Bottom of Insulation Elevation (mm) = Upper End Bottom of Insulation Elevation (mm) | Lower End Obvert Elevation (mm) = Upper End Obvert Elevation (mm) | Lower End Top Elevation (mm) = Upper End Top Elevation (mm) = Lower End Top of Insulation Elevation (mm) = Upper End Top of Insulation Elevation (mm) | Inside Diameter (mm) | Outside Diameter (mm) | Size = Overall Size | Wall Thickness (mm) | Area (m2) | Diameter (mm) | System Name = Group | Relative Roughness
1149513 | -4.3 | -6 | 4.3 | 6 | 8.6 | 12 | 10 mmø | 1.7 | 0.0314159 | 10 | Domestic Cold Water 2 | 0.000813953
1149987 | -5.8 | -8 | 5.8 | 8 | 11.6 | 16 | 12 mmø | 2.2 | 0.0376991 | 12 | Domestic Cold Water 9 | 0.000603448
1150002 | -7.2 | -10 | 7.2 | 10 | 14.4 | 20 | 15 mmø | 2.8 | 0.0471239 | 15 | Domestic Cold Water 10 | 0.000486111
1150007 | -9 | -12.5 | 9 | 12.5 | 18 | 25 | 20 mmø | 3.5 | 0.0628319 | 20 | Domestic Cold Water 11 | 0.000388889
1150012 | -11.6 | -16 | 11.6 | 16 | 23.2 | 32 | 25 mmø | 4.4 | 0.0785398 | 25 | Domestic Cold Water 12 | 0.000301724
1150017 | -14.5 | -20 | 14.5 | 20 | 29 | 40 | 32 mmø | 5.5 | 0.100531 | 32 | Domestic Cold Water 13 | 0.000241379
1150022 | -18.1 | -25 | 18.1 | 25 | 36.2 | 50 | 40 mmø | 6.9 | 0.125664 | 40 | Domestic Cold Water 14 | 0.00019337
1150027 | -22.9 | -31.5 | 22.9 | 31.5 | 45.8 | 63 | 50 mmø | 8.6 | 0.15708 | 50 | Domestic Cold Water 15 | 0.000152838
