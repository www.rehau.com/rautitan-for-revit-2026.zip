Properties of the parts of a building model (IFC4), part 9 of 10

# IfcPipeFitting: Sleeve:PX 7,4 (450)
Name (Sleeve:PX 7,4:...) | Language Tender Text | Region URL | DN1 (mm) | L1 (mm) | Volume (m3) | Description long | GTIN | PID | Product Group | Product URL | Weight
1078875 | Tender Text en | Product URL DE | 15 | 25 | 0.00000516767 | REHAU Compression sleeve RAUTITAN PX 20 | 4007360361211 | 11600021001 | 1949 | https://oxomi.com/p/3000126/datasheet/-/11600021001 | 0.011
1078881 | Tender Text en | Product URL DE | 20 | 27.2 | 0.0000087028 | REHAU Compression sleeve RAUTITAN PX 25 | 4007360361228 | 11600031001 | 1950 | https://oxomi.com/p/3000126/datasheet/-/11600031001 | 0.015828
1078883 | Tender Text en | Product URL DE | 25 | 34 | 0.0000174355 | REHAU Compression sleeve RAUTITAN PX 32 | 4007360361235 | 11600041001 | 1951 | https://oxomi.com/p/3000126/datasheet/-/11600041001 | 0.027828
1078889 | Tender Text en | Product URL DE | 25 | 34 | 0.0000174355 | REHAU Compression sleeve RAUTITAN PX 32 | 4007360361235 | 11600041001 | 1951 | https://oxomi.com/p/3000126/datasheet/-/11600041001 | 0.027828
1078905 | Tender Text en | Product URL DE | 15 | 25 | 0.00000516767 | REHAU Compression sleeve RAUTITAN PX 20 | 4007360361211 | 11600021001 | 1949 | https://oxomi.com/p/3000126/datasheet/-/11600021001 | 0.011
1078907 | Tender Text en | Product URL DE | 20 | 27.2 | 0.0000087028 | REHAU Compression sleeve RAUTITAN PX 25 | 4007360361228 | 11600031001 | 1950 | https://oxomi.com/p/3000126/datasheet/-/11600031001 | 0.015828
1078909 | Tender Text en | Product URL DE | 20 | 27.2 | 0.0000087028 | REHAU Compression sleeve RAUTITAN PX 25 | 4007360361228 | 11600031001 | 1950 | https://oxomi.com/p/3000126/datasheet/-/11600031001 | 0.015828
1078911 | Tender Text en | Product URL DE | 25 | 34 | 0.0000174355 | REHAU Compression sleeve RAUTITAN PX 32 | 4007360361235 | 11600041001 | 1951 | https://oxomi.com/p/3000126/datasheet/-/11600041001 | 0.027828
1078913 | Tender Text en | Product URL DE | 15 | 25 | 0.00000516767 | REHAU Compression sleeve RAUTITAN PX 20 | 4007360361211 | 11600021001 | 1949 | https://oxomi.com/p/3000126/datasheet/-/11600021001 | 0.011
1078919 | Tender Text en | Product URL DE | 15 | 25 | 0.00000516767 | REHAU Compression sleeve RAUTITAN PX 20 | 4007360361211 | 11600021001 | 1949 | https://oxomi.com/p/3000126/datasheet/-/11600021001 | 0.011
1078921 | Tender Text en | Product URL DE | 20 | 27.2 | 0.0000087028 | REHAU Compression sleeve RAUTITAN PX 25 | 4007360361228 | 11600031001 | 1950 | https://oxomi.com/p/3000126/datasheet/-/11600031001 | 0.015828
1078923 | Tender Text en | Product URL DE | 32 | 37.8 | 0.0000303041 | REHAU Compression sleeve RAUTITAN PX 40 | 4007360361242 | 11600051001 | 1952 | https://oxomi.com/p/3000126/datasheet/-/11600051001 | 0.03861
1078927 | Tender Text en | Product URL DE | 15 | 25 | 0.00000516767 | REHAU Compression sleeve RAUTITAN PX 20 | 4007360361211 | 11600021001 | 1949 | https://oxomi.com/p/3000126/datasheet/-/11600021001 | 0.011
1078929 | Tender Text en | Product URL DE | 25 | 34 | 0.0000174355 | REHAU Compression sleeve RAUTITAN PX 32 | 4007360361235 | 11600041001 | 1951 | https://oxomi.com/p/3000126/datasheet/-/11600041001 | 0.027828
1078931 | Tender Text en | Product URL DE | 32 | 37.8 | 0.0000303041 | REHAU Compression sleeve RAUTITAN PX 40 | 4007360361242 | 11600051001 | 1952 | https://oxomi.com/p/3000126/datasheet/-/11600051001 | 0.03861
1078933 | Tender Text en | Product URL DE | 20 | 27.2 | 0.0000087028 | REHAU Compression sleeve RAUTITAN PX 25 | 4007360361228 | 11600031001 | 1950 | https://oxomi.com/p/3000126/datasheet/-/11600031001 | 0.015828
1078935 | Tender Text en | Product URL DE | 25 | 34 | 0.0000174355 | REHAU Compression sleeve RAUTITAN PX 32 | 4007360361235 | 11600041001 | 1951 | https://oxomi.com/p/3000126/datasheet/-/11600041001 | 0.027828
1078937 | Tender Text en | Product URL DE | 15 | 25 | 0.00000516767 | REHAU Compression sleeve RAUTITAN PX 20 | 4007360361211 | 11600021001 | 1949 | https://oxomi.com/p/3000126/datasheet/-/11600021001 | 0.011
1078939 | Tender Text en | Product URL DE | 20 | 27.2 | 0.0000087028 | REHAU Compression sleeve RAUTITAN PX 25 | 4007360361228 | 11600031001 | 1950 | https://oxomi.com/p/3000126/datasheet/-/11600031001 | 0.015828
1078941 | Tender Text en | Product URL DE | 15 | 25 | 0.00000516767 | REHAU Compression sleeve RAUTITAN PX 20 | 4007360361211 | 11600021001 | 1949 | https://oxomi.com/p/3000126/datasheet/-/11600021001 | 0.011
1078943 | Tender Text en | Product URL DE | 15 | 25 | 0.00000516767 | REHAU Compression sleeve RAUTITAN PX 20 | 4007360361211 | 11600021001 | 1949 | https://oxomi.com/p/3000126/datasheet/-/11600021001 | 0.011
1078945 | Tender Text en | Product URL DE | 20 | 27.2 | 0.0000087028 | REHAU Compression sleeve RAUTITAN PX 25 | 4007360361228 | 11600031001 | 1950 | https://oxomi.com/p/3000126/datasheet/-/11600031001 | 0.015828
1078947 | Tender Text en | Product URL DE | 32 | 37.8 | 0.0000303041 | REHAU Compression sleeve RAUTITAN PX 40 | 4007360361242 | 11600051001 | 1952 | https://oxomi.com/p/3000126/datasheet/-/11600051001 | 0.03861
1078949 | Tender Text en | Product URL DE | 25 | 34 | 0.0000174355 | REHAU Compression sleeve RAUTITAN PX 32 | 4007360361235 | 11600041001 | 1951 | https://oxomi.com/p/3000126/datasheet/-/11600041001 | 0.027828
1078951 | Tender Text en | Product URL DE | 25 | 34 | 0.0000174355 | REHAU Compression sleeve RAUTITAN PX 32 | 4007360361235 | 11600041001 | 1951 | https://oxomi.com/p/3000126/datasheet/-/11600041001 | 0.027828
1078953 | Tender Text en | Product URL DE | 20 | 27.2 | 0.0000087028 | REHAU Compression sleeve RAUTITAN PX 25 | 4007360361228 | 11600031001 | 1950 | https://oxomi.com/p/3000126/datasheet/-/11600031001 | 0.015828
1078955 | Tender Text en | Product URL DE | 20 | 27.2 | 0.0000087028 | REHAU Compression sleeve RAUTITAN PX 25 | 4007360361228 | 11600031001 | 1950 | https://oxomi.com/p/3000126/datasheet/-/11600031001 | 0.015828
1078957 | Tender Text en | Product URL DE | 15 | 25 | 0.00000516767 | REHAU Compression sleeve RAUTITAN PX 20 | 4007360361211 | 11600021001 | 1949 | https://oxomi.com/p/3000126/datasheet/-/11600021001 | 0.011
1078959 | Tender Text en | Product URL DE | 15 | 25 | 0.00000516767 | REHAU Compression sleeve RAUTITAN PX 20 | 4007360361211 | 11600021001 | 1949 | https://oxomi.com/p/3000126/datasheet/-/11600021001 | 0.011
1078961 | Tender Text en | Product URL DE | 12 | 23.7 | 0.00000312848 | REHAU Compression sleeve RAUTITAN PX 16 | 4007360361204 | 11600011001 | 1947 | https://oxomi.com/p/3000126/datasheet/-/11600011001 | 0.0076
1078969 | Tender Text en | Product URL DE | 32 | 37.8 | 0.0000303041 | REHAU Compression sleeve RAUTITAN PX 40 | 4007360361242 | 11600051001 | 1952 | https://oxomi.com/p/3000126/datasheet/-/11600051001 | 0.03861
1078975 | Tender Text en | Product URL DE | 32 | 37.8 | 0.0000303041 | REHAU Compression sleeve RAUTITAN PX 40 | 4007360361242 | 11600051001 | 1952 | https://oxomi.com/p/3000126/datasheet/-/11600051001 | 0.03861
1078977 | Tender Text en | Product URL DE | 25 | 34 | 0.0000174355 | REHAU Compression sleeve RAUTITAN PX 32 | 4007360361235 | 11600041001 | 1951 | https://oxomi.com/p/3000126/datasheet/-/11600041001 | 0.027828
1078979 | Tender Text en | Product URL DE | 25 | 34 | 0.0000174355 | REHAU Compression sleeve RAUTITAN PX 32 | 4007360361235 | 11600041001 | 1951 | https://oxomi.com/p/3000126/datasheet/-/11600041001 | 0.027828
1078981 | Tender Text en | Product URL DE | 20 | 27.2 | 0.0000087028 | REHAU Compression sleeve RAUTITAN PX 25 | 4007360361228 | 11600031001 | 1950 | https://oxomi.com/p/3000126/datasheet/-/11600031001 | 0.015828
1078983 | Tender Text en | Product URL DE | 20 | 27.2 | 0.0000087028 | REHAU Compression sleeve RAUTITAN PX 25 | 4007360361228 | 11600031001 | 1950 | https://oxomi.com/p/3000126/datasheet/-/11600031001 | 0.015828
1078985 | Tender Text en | Product URL DE | 15 | 25 | 0.00000516767 | REHAU Compression sleeve RAUTITAN PX 20 | 4007360361211 | 11600021001 | 1949 | https://oxomi.com/p/3000126/datasheet/-/11600021001 | 0.011
1078987 | Tender Text en | Product URL DE | 15 | 25 | 0.00000516767 | REHAU Compression sleeve RAUTITAN PX 20 | 4007360361211 | 11600021001 | 1949 | https://oxomi.com/p/3000126/datasheet/-/11600021001 | 0.011
1078989 | Tender Text en | Product URL DE | 12 | 23.7 | 0.00000312848 | REHAU Compression sleeve RAUTITAN PX 16 | 4007360361204 | 11600011001 | 1947 | https://oxomi.com/p/3000126/datasheet/-/11600011001 | 0.0076
1078991 | Tender Text en | Product URL DE | 20 | 27.2 | 0.0000087028 | REHAU Compression sleeve RAUTITAN PX 25 | 4007360361228 | 11600031001 | 1950 | https://oxomi.com/p/3000126/datasheet/-/11600031001 | 0.015828
1078993 | Tender Text en | Product URL DE | 12 | 23.7 | 0.00000312848 | REHAU Compression sleeve RAUTITAN PX 16 | 4007360361204 | 11600011001 | 1947 | https://oxomi.com/p/3000126/datasheet/-/11600011001 | 0.0076
1078995 | Tender Text en | Product URL DE | 40 | 45 | 0.0000353695 | REHAU Compr. sleeve RAUTITAN PX stabil 50 | 4062178755416 | 11602061001 | 1954 | https://oxomi.com/p/3000126/datasheet/-/11602061001 | 0.0673
1078997 | Tender Text en | Product URL DE | 32 | 37.8 | 0.0000303041 | REHAU Compression sleeve RAUTITAN PX 40 | 4007360361242 | 11600051001 | 1952 | https://oxomi.com/p/3000126/datasheet/-/11600051001 | 0.03861
1078999 | Tender Text en | Product URL DE | 50 | 53 | 0.0000702282 | REHAU Compr. sleeve RAUTITAN PX stabil 63 | 4062178755423 | 11602071001 | 1955 | https://oxomi.com/p/3000126/datasheet/-/11602071001 | 0.1106
1079001 | Tender Text en | Product URL DE | 40 | 45 | 0.0000353695 | REHAU Compr. sleeve RAUTITAN PX stabil 50 | 4062178755416 | 11602061001 | 1954 | https://oxomi.com/p/3000126/datasheet/-/11602061001 | 0.0673
1079003 | Tender Text en | Product URL DE | 40 | 45 | 0.0000353695 | REHAU Compr. sleeve RAUTITAN PX stabil 50 | 4062178755416 | 11602061001 | 1954 | https://oxomi.com/p/3000126/datasheet/-/11602061001 | 0.0673
1079005 | Tender Text en | Product URL DE | 25 | 34 | 0.0000174355 | REHAU Compression sleeve RAUTITAN PX 32 | 4007360361235 | 11600041001 | 1951 | https://oxomi.com/p/3000126/datasheet/-/11600041001 | 0.027828
1079007 | Tender Text en | Product URL DE | 32 | 37.8 | 0.0000303041 | REHAU Compression sleeve RAUTITAN PX 40 | 4007360361242 | 11600051001 | 1952 | https://oxomi.com/p/3000126/datasheet/-/11600051001 | 0.03861
1079009 | Tender Text en | Product URL DE | 20 | 27.2 | 0.0000087028 | REHAU Compression sleeve RAUTITAN PX 25 | 4007360361228 | 11600031001 | 1950 | https://oxomi.com/p/3000126/datasheet/-/11600031001 | 0.015828
1079013 | Tender Text en | Product URL DE | 32 | 37.8 | 0.0000303041 | REHAU Compression sleeve RAUTITAN PX 40 | 4007360361242 | 11600051001 | 1952 | https://oxomi.com/p/3000126/datasheet/-/11600051001 | 0.03861
1079019 | Tender Text en | Product URL DE | 25 | 34 | 0.0000174355 | REHAU Compression sleeve RAUTITAN PX 32 | 4007360361235 | 11600041001 | 1951 | https://oxomi.com/p/3000126/datasheet/-/11600041001 | 0.027828
1079021 | Tender Text en | Product URL DE | 20 | 27.2 | 0.0000087028 | REHAU Compression sleeve RAUTITAN PX 25 | 4007360361228 | 11600031001 | 1950 | https://oxomi.com/p/3000126/datasheet/-/11600031001 | 0.015828
1079023 | Tender Text en | Product URL DE | 20 | 27.2 | 0.0000087028 | REHAU Compression sleeve RAUTITAN PX 25 | 4007360361228 | 11600031001 | 1950 | https://oxomi.com/p/3000126/datasheet/-/11600031001 | 0.015828
1079025 | Tender Text en | Product URL DE | 15 | 25 | 0.00000516767 | REHAU Compression sleeve RAUTITAN PX 20 | 4007360361211 | 11600021001 | 1949 | https://oxomi.com/p/3000126/datasheet/-/11600021001 | 0.011
1079029 | Tender Text en | Product URL DE | 25 | 34 | 0.0000174355 | REHAU Compression sleeve RAUTITAN PX 32 | 4007360361235 | 11600041001 | 1951 | https://oxomi.com/p/3000126/datasheet/-/11600041001 | 0.027828
1079031 | Tender Text en | Product URL DE | 12 | 23.7 | 0.00000312848 | REHAU Compression sleeve RAUTITAN PX 16 | 4007360361204 | 11600011001 | 1947 | https://oxomi.com/p/3000126/datasheet/-/11600011001 | 0.0076
1079033 | Tender Text en | Product URL DE | 12 | 23.7 | 0.00000312848 | REHAU Compression sleeve RAUTITAN PX 16 | 4007360361204 | 11600011001 | 1947 | https://oxomi.com/p/3000126/datasheet/-/11600011001 | 0.0076
1079035 | Tender Text en | Product URL DE | 15 | 25 | 0.00000516767 | REHAU Compression sleeve RAUTITAN PX 20 | 4007360361211 | 11600021001 | 1949 | https://oxomi.com/p/3000126/datasheet/-/11600021001 | 0.011
1079037 | Tender Text en | Product URL DE | 15 | 25 | 0.00000516767 | REHAU Compression sleeve RAUTITAN PX 20 | 4007360361211 | 11600021001 | 1949 | https://oxomi.com/p/3000126/datasheet/-/11600021001 | 0.011
1079039 | Tender Text en | Product URL DE | 20 | 27.2 | 0.0000087028 | REHAU Compression sleeve RAUTITAN PX 25 | 4007360361228 | 11600031001 | 1950 | https://oxomi.com/p/3000126/datasheet/-/11600031001 | 0.015828
1079041 | Tender Text en | Product URL DE | 20 | 27.2 | 0.0000087028 | REHAU Compression sleeve RAUTITAN PX 25 | 4007360361228 | 11600031001 | 1950 | https://oxomi.com/p/3000126/datasheet/-/11600031001 | 0.015828
1079043 | Tender Text en | Product URL DE | 25 | 34 | 0.0000174355 | REHAU Compression sleeve RAUTITAN PX 32 | 4007360361235 | 11600041001 | 1951 | https://oxomi.com/p/3000126/datasheet/-/11600041001 | 0.027828
1079045 | Tender Text en | Product URL DE | 25 | 34 | 0.0000174355 | REHAU Compression sleeve RAUTITAN PX 32 | 4007360361235 | 11600041001 | 1951 | https://oxomi.com/p/3000126/datasheet/-/11600041001 | 0.027828
1079047 | Tender Text en | Product URL DE | 32 | 37.8 | 0.0000303041 | REHAU Compression sleeve RAUTITAN PX 40 | 4007360361242 | 11600051001 | 1952 | https://oxomi.com/p/3000126/datasheet/-/11600051001 | 0.03861
1079049 | Tender Text en | Product URL DE | 32 | 37.8 | 0.0000303041 | REHAU Compression sleeve RAUTITAN PX 40 | 4007360361242 | 11600051001 | 1952 | https://oxomi.com/p/3000126/datasheet/-/11600051001 | 0.03861
1081596 | Tender Text en | Product URL DE | 12 | 23.7 | 0.00000312848 | REHAU Compression sleeve RAUTITAN PX 16 | 4007360361204 | 11600011001 | 1947 | https://oxomi.com/p/3000126/datasheet/-/11600011001 | 0.0076
1081598 | Tender Text en | Product URL DE | 12 | 23.7 | 0.00000312848 | REHAU Compression sleeve RAUTITAN PX 16 | 4007360361204 | 11600011001 | 1947 | https://oxomi.com/p/3000126/datasheet/-/11600011001 | 0.0076
1081602 | Tender Text en | Product URL DE | 15 | 25 | 0.00000516767 | REHAU Compression sleeve RAUTITAN PX 20 | 4007360361211 | 11600021001 | 1949 | https://oxomi.com/p/3000126/datasheet/-/11600021001 | 0.011
1081604 | Tender Text en | Product URL DE | 15 | 25 | 0.00000516767 | REHAU Compression sleeve RAUTITAN PX 20 | 4007360361211 | 11600021001 | 1949 | https://oxomi.com/p/3000126/datasheet/-/11600021001 | 0.011
1081608 | Tender Text en | Product URL DE | 20 | 27.2 | 0.0000087028 | REHAU Compression sleeve RAUTITAN PX 25 | 4007360361228 | 11600031001 | 1950 | https://oxomi.com/p/3000126/datasheet/-/11600031001 | 0.015828
1081610 | Tender Text en | Product URL DE | 20 | 27.2 | 0.0000087028 | REHAU Compression sleeve RAUTITAN PX 25 | 4007360361228 | 11600031001 | 1950 | https://oxomi.com/p/3000126/datasheet/-/11600031001 | 0.015828
1081614 | Tender Text en | Product URL DE | 25 | 34 | 0.0000174355 | REHAU Compression sleeve RAUTITAN PX 32 | 4007360361235 | 11600041001 | 1951 | https://oxomi.com/p/3000126/datasheet/-/11600041001 | 0.027828
1081616 | Tender Text en | Product URL DE | 25 | 34 | 0.0000174355 | REHAU Compression sleeve RAUTITAN PX 32 | 4007360361235 | 11600041001 | 1951 | https://oxomi.com/p/3000126/datasheet/-/11600041001 | 0.027828
1081618 | Tender Text en | Product URL DE | 32 | 37.8 | 0.0000303041 | REHAU Compression sleeve RAUTITAN PX 40 | 4007360361242 | 11600051001 | 1952 | https://oxomi.com/p/3000126/datasheet/-/11600051001 | 0.03861
1081620 | Tender Text en | Product URL DE | 32 | 37.8 | 0.0000303041 | REHAU Compression sleeve RAUTITAN PX 40 | 4007360361242 | 11600051001 | 1952 | https://oxomi.com/p/3000126/datasheet/-/11600051001 | 0.03861
1084065 | Tender Text en | Product URL DE | 40 | 45 | 0.0000353695 | REHAU Compr. sleeve RAUTITAN PX stabil 50 | 4062178755416 | 11602061001 | 1954 | https://oxomi.com/p/3000126/datasheet/-/11602061001 | 0.0673
1084067 | Tender Text en | Product URL DE | 40 | 45 | 0.0000353695 | REHAU Compr. sleeve RAUTITAN PX stabil 50 | 4062178755416 | 11602061001 | 1954 | https://oxomi.com/p/3000126/datasheet/-/11602061001 | 0.0673
1084069 | Tender Text en | Product URL DE | 50 | 53 | 0.0000702282 | REHAU Compr. sleeve RAUTITAN PX stabil 63 | 4062178755423 | 11602071001 | 1955 | https://oxomi.com/p/3000126/datasheet/-/11602071001 | 0.1106
1084071 | Tender Text en | Product URL DE | 50 | 53 | 0.0000702282 | REHAU Compr. sleeve RAUTITAN PX stabil 63 | 4062178755423 | 11602071001 | 1955 | https://oxomi.com/p/3000126/datasheet/-/11602071001 | 0.1106
1086519 | Tender Text en | Product URL DE | 15 | 25 | 0.00000516767 | REHAU Compression sleeve RAUTITAN PX 20 | 4007360361211 | 11600021001 | 1949 | https://oxomi.com/p/3000126/datasheet/-/11600021001 | 0.011
1086521 | Tender Text en | Product URL DE | 15 | 25 | 0.00000516767 | REHAU Compression sleeve RAUTITAN PX 20 | 4007360361211 | 11600021001 | 1949 | https://oxomi.com/p/3000126/datasheet/-/11600021001 | 0.011
1086525 | Tender Text en | Product URL DE | 20 | 27.2 | 0.0000087028 | REHAU Compression sleeve RAUTITAN PX 25 | 4007360361228 | 11600031001 | 1950 | https://oxomi.com/p/3000126/datasheet/-/11600031001 | 0.015828
1086527 | Tender Text en | Product URL DE | 20 | 27.2 | 0.0000087028 | REHAU Compression sleeve RAUTITAN PX 25 | 4007360361228 | 11600031001 | 1950 | https://oxomi.com/p/3000126/datasheet/-/11600031001 | 0.015828
1086531 | Tender Text en | Product URL DE | 25 | 34 | 0.0000174355 | REHAU Compression sleeve RAUTITAN PX 32 | 4007360361235 | 11600041001 | 1951 | https://oxomi.com/p/3000126/datasheet/-/11600041001 | 0.027828
1086533 | Tender Text en | Product URL DE | 25 | 34 | 0.0000174355 | REHAU Compression sleeve RAUTITAN PX 32 | 4007360361235 | 11600041001 | 1951 | https://oxomi.com/p/3000126/datasheet/-/11600041001 | 0.027828
1441483 | Tender Text en | Product URL DE | 15 | 25 | 0.00000516767 | REHAU Compression sleeve RAUTITAN PX 20 | 4007360361211 | 11600021001 | 1949 | https://oxomi.com/p/3000126/datasheet/-/11600021001 | 0.011
1441484 | Tender Text en | Product URL DE | 15 | 25 | 0.00000516767 | REHAU Compression sleeve RAUTITAN PX 20 | 4007360361211 | 11600021001 | 1949 | https://oxomi.com/p/3000126/datasheet/-/11600021001 | 0.011
1441968 | Tender Text en | Product URL DE | 12 | 23.7 | 0.00000312848 | REHAU Compression sleeve RAUTITAN PX 16 | 4007360361204 | 11600011001 | 1947 | https://oxomi.com/p/3000126/datasheet/-/11600011001 | 0.0076
1442035 | Tender Text en | Product URL DE | 15 | 25 | 0.00000516767 | REHAU Compression sleeve RAUTITAN PX 20 | 4007360361211 | 11600021001 | 1949 | https://oxomi.com/p/3000126/datasheet/-/11600021001 | 0.011
1442378 | Tender Text en | Product URL DE | 12 | 23.7 | 0.00000312848 | REHAU Compression sleeve RAUTITAN PX 16 | 4007360361204 | 11600011001 | 1947 | https://oxomi.com/p/3000126/datasheet/-/11600011001 | 0.0076
1442379 | Tender Text en | Product URL DE | 12 | 23.7 | 0.00000312848 | REHAU Compression sleeve RAUTITAN PX 16 | 4007360361204 | 11600011001 | 1947 | https://oxomi.com/p/3000126/datasheet/-/11600011001 | 0.0076
1442401 | Tender Text en | Product URL DE | 15 | 25 | 0.00000516767 | REHAU Compression sleeve RAUTITAN PX 20 | 4007360361211 | 11600021001 | 1949 | https://oxomi.com/p/3000126/datasheet/-/11600021001 | 0.011
1442405 | Tender Text en | Product URL DE | 12 | 23.7 | 0.00000312848 | REHAU Compression sleeve RAUTITAN PX 16 | 4007360361204 | 11600011001 | 1947 | https://oxomi.com/p/3000126/datasheet/-/11600011001 | 0.0076
1443067 | Tender Text en | Product URL DE | 40 | 45 | 0.0000353695 | REHAU Compr. sleeve RAUTITAN PX stabil 50 | 4062178755416 | 11602061001 | 1954 | https://oxomi.com/p/3000126/datasheet/-/11602061001 | 0.0673
1443071 | Tender Text en | Product URL DE | 50 | 53 | 0.0000702282 | REHAU Compr. sleeve RAUTITAN PX stabil 63 | 4062178755423 | 11602071001 | 1955 | https://oxomi.com/p/3000126/datasheet/-/11602071001 | 0.1106
1443668 | Tender Text en | Product URL DE | 12 | 23.7 | 0.00000312848 | REHAU Compression sleeve RAUTITAN PX 16 | 4007360361204 | 11600011001 | 1947 | https://oxomi.com/p/3000126/datasheet/-/11600011001 | 0.0076
1443732 | Tender Text en | Product URL DE | 15 | 25 | 0.00000516767 | REHAU Compression sleeve RAUTITAN PX 20 | 4007360361211 | 11600021001 | 1949 | https://oxomi.com/p/3000126/datasheet/-/11600021001 | 0.011
1443736 | Tender Text en | Product URL DE | 15 | 25 | 0.00000516767 | REHAU Compression sleeve RAUTITAN PX 20 | 4007360361211 | 11600021001 | 1949 | https://oxomi.com/p/3000126/datasheet/-/11600021001 | 0.011
1443740 | Tender Text en | Product URL DE | 20 | 27.2 | 0.0000087028 | REHAU Compression sleeve RAUTITAN PX 25 | 4007360361228 | 11600031001 | 1950 | https://oxomi.com/p/3000126/datasheet/-/11600031001 | 0.015828
1443744 | Tender Text en | Product URL DE | 20 | 27.2 | 0.0000087028 | REHAU Compression sleeve RAUTITAN PX 25 | 4007360361228 | 11600031001 | 1950 | https://oxomi.com/p/3000126/datasheet/-/11600031001 | 0.015828
1443748 | Tender Text en | Product URL DE | 25 | 34 | 0.0000174355 | REHAU Compression sleeve RAUTITAN PX 32 | 4007360361235 | 11600041001 | 1951 | https://oxomi.com/p/3000126/datasheet/-/11600041001 | 0.027828
1443752 | Tender Text en | Product URL DE | 25 | 34 | 0.0000174355 | REHAU Compression sleeve RAUTITAN PX 32 | 4007360361235 | 11600041001 | 1951 | https://oxomi.com/p/3000126/datasheet/-/11600041001 | 0.027828
1443756 | Tender Text en | Product URL DE | 32 | 37.8 | 0.0000303041 | REHAU Compression sleeve RAUTITAN PX 40 | 4007360361242 | 11600051001 | 1952 | https://oxomi.com/p/3000126/datasheet/-/11600051001 | 0.03861
1443804 | Tender Text en | Product URL DE | 20 | 27.2 | 0.0000087028 | REHAU Compression sleeve RAUTITAN PX 25 | 4007360361228 | 11600031001 | 1950 | https://oxomi.com/p/3000126/datasheet/-/11600031001 | 0.015828
1444899 | Tender Text en | Product URL DE | 12 | 23.7 | 0.00000312848 | REHAU Compression sleeve RAUTITAN PX 16 | 4007360361204 | 11600011001 | 1947 | https://oxomi.com/p/3000126/datasheet/-/11600011001 | 0.0076
1444903 | Tender Text en | Product URL DE | 25 | 34 | 0.0000174355 | REHAU Compression sleeve RAUTITAN PX 32 | 4007360361235 | 11600041001 | 1951 | https://oxomi.com/p/3000126/datasheet/-/11600041001 | 0.027828
1444904 | Tender Text en | Product URL DE | 20 | 27.2 | 0.0000087028 | REHAU Compression sleeve RAUTITAN PX 25 | 4007360361228 | 11600031001 | 1950 | https://oxomi.com/p/3000126/datasheet/-/11600031001 | 0.015828
1444905 | Tender Text en | Product URL DE | 12 | 23.7 | 0.00000312848 | REHAU Compression sleeve RAUTITAN PX 16 | 4007360361204 | 11600011001 | 1947 | https://oxomi.com/p/3000126/datasheet/-/11600011001 | 0.0076
1444913 | Tender Text en | Product URL DE | 12 | 23.7 | 0.00000312848 | REHAU Compression sleeve RAUTITAN PX 16 | 4007360361204 | 11600011001 | 1947 | https://oxomi.com/p/3000126/datasheet/-/11600011001 | 0.0076
1444914 | Tender Text en | Product URL DE | 12 | 23.7 | 0.00000312848 | REHAU Compression sleeve RAUTITAN PX 16 | 4007360361204 | 11600011001 | 1947 | https://oxomi.com/p/3000126/datasheet/-/11600011001 | 0.0076
1444919 | Tender Text en | Product URL DE | 12 | 23.7 | 0.00000312848 | REHAU Compression sleeve RAUTITAN PX 16 | 4007360361204 | 11600011001 | 1947 | https://oxomi.com/p/3000126/datasheet/-/11600011001 | 0.0076
1444920 | Tender Text en | Product URL DE | 12 | 23.7 | 0.00000312848 | REHAU Compression sleeve RAUTITAN PX 16 | 4007360361204 | 11600011001 | 1947 | https://oxomi.com/p/3000126/datasheet/-/11600011001 | 0.0076
1444921 | Tender Text en | Product URL DE | 12 | 23.7 | 0.00000312848 | REHAU Compression sleeve RAUTITAN PX 16 | 4007360361204 | 11600011001 | 1947 | https://oxomi.com/p/3000126/datasheet/-/11600011001 | 0.0076
1444927 | Tender Text en | Product URL DE | 12 | 23.7 | 0.00000312848 | REHAU Compression sleeve RAUTITAN PX 16 | 4007360361204 | 11600011001 | 1947 | https://oxomi.com/p/3000126/datasheet/-/11600011001 | 0.0076
1444931 | Tender Text en | Product URL DE | 12 | 23.7 | 0.00000312848 | REHAU Compression sleeve RAUTITAN PX 16 | 4007360361204 | 11600011001 | 1947 | https://oxomi.com/p/3000126/datasheet/-/11600011001 | 0.0076
1444941 | Tender Text en | Product URL DE | 20 | 27.2 | 0.0000087028 | REHAU Compression sleeve RAUTITAN PX 25 | 4007360361228 | 11600031001 | 1950 | https://oxomi.com/p/3000126/datasheet/-/11600031001 | 0.015828
1444942 | Tender Text en | Product URL DE | 20 | 27.2 | 0.0000087028 | REHAU Compression sleeve RAUTITAN PX 25 | 4007360361228 | 11600031001 | 1950 | https://oxomi.com/p/3000126/datasheet/-/11600031001 | 0.015828
1444947 | Tender Text en | Product URL DE | 15 | 25 | 0.00000516767 | REHAU Compression sleeve RAUTITAN PX 20 | 4007360361211 | 11600021001 | 1949 | https://oxomi.com/p/3000126/datasheet/-/11600021001 | 0.011
1444948 | Tender Text en | Product URL DE | 15 | 25 | 0.00000516767 | REHAU Compression sleeve RAUTITAN PX 20 | 4007360361211 | 11600021001 | 1949 | https://oxomi.com/p/3000126/datasheet/-/11600021001 | 0.011
1444953 | Tender Text en | Product URL DE | 12 | 23.7 | 0.00000312848 | REHAU Compression sleeve RAUTITAN PX 16 | 4007360361204 | 11600011001 | 1947 | https://oxomi.com/p/3000126/datasheet/-/11600011001 | 0.0076
1444954 | Tender Text en | Product URL DE | 12 | 23.7 | 0.00000312848 | REHAU Compression sleeve RAUTITAN PX 16 | 4007360361204 | 11600011001 | 1947 | https://oxomi.com/p/3000126/datasheet/-/11600011001 | 0.0076
1444959 | Tender Text en | Product URL DE | 12 | 23.7 | 0.00000312848 | REHAU Compression sleeve RAUTITAN PX 16 | 4007360361204 | 11600011001 | 1947 | https://oxomi.com/p/3000126/datasheet/-/11600011001 | 0.0076
1444964 | Tender Text en | Product URL DE | 15 | 25 | 0.00000516767 | REHAU Compression sleeve RAUTITAN PX 20 | 4007360361211 | 11600021001 | 1949 | https://oxomi.com/p/3000126/datasheet/-/11600021001 | 0.011
1444968 | Tender Text en | Product URL DE | 15 | 25 | 0.00000516767 | REHAU Compression sleeve RAUTITAN PX 20 | 4007360361211 | 11600021001 | 1949 | https://oxomi.com/p/3000126/datasheet/-/11600021001 | 0.011
1444972 | Tender Text en | Product URL DE | 20 | 27.2 | 0.0000087028 | REHAU Compression sleeve RAUTITAN PX 25 | 4007360361228 | 11600031001 | 1950 | https://oxomi.com/p/3000126/datasheet/-/11600031001 | 0.015828
1444976 | Tender Text en | Product URL DE | 20 | 27.2 | 0.0000087028 | REHAU Compression sleeve RAUTITAN PX 25 | 4007360361228 | 11600031001 | 1950 | https://oxomi.com/p/3000126/datasheet/-/11600031001 | 0.015828
1444980 | Tender Text en | Product URL DE | 25 | 34 | 0.0000174355 | REHAU Compression sleeve RAUTITAN PX 32 | 4007360361235 | 11600041001 | 1951 | https://oxomi.com/p/3000126/datasheet/-/11600041001 | 0.027828
1444984 | Tender Text en | Product URL DE | 25 | 34 | 0.0000174355 | REHAU Compression sleeve RAUTITAN PX 32 | 4007360361235 | 11600041001 | 1951 | https://oxomi.com/p/3000126/datasheet/-/11600041001 | 0.027828
1444988 | Tender Text en | Product URL DE | 25 | 34 | 0.0000174355 | REHAU Compression sleeve RAUTITAN PX 32 | 4007360361235 | 11600041001 | 1951 | https://oxomi.com/p/3000126/datasheet/-/11600041001 | 0.027828
1444992 | Tender Text en | Product URL DE | 32 | 37.8 | 0.0000303041 | REHAU Compression sleeve RAUTITAN PX 40 | 4007360361242 | 11600051001 | 1952 | https://oxomi.com/p/3000126/datasheet/-/11600051001 | 0.03861
1444996 | Tender Text en | Product URL DE | 40 | 45 | 0.0000353695 | REHAU Compr. sleeve RAUTITAN PX stabil 50 | 4062178755416 | 11602061001 | 1954 | https://oxomi.com/p/3000126/datasheet/-/11602061001 | 0.0673
1445000 | Tender Text en | Product URL DE | 50 | 53 | 0.0000702282 | REHAU Compr. sleeve RAUTITAN PX stabil 63 | 4062178755423 | 11602071001 | 1955 | https://oxomi.com/p/3000126/datasheet/-/11602071001 | 0.1106
1445003 | Tender Text en | Product URL DE | 32 | 37.8 | 0.0000303041 | REHAU Compression sleeve RAUTITAN PX 40 | 4007360361242 | 11600051001 | 1952 | https://oxomi.com/p/3000126/datasheet/-/11600051001 | 0.03861
1445004 | Tender Text en | Product URL DE | 25 | 34 | 0.0000174355 | REHAU Compression sleeve RAUTITAN PX 32 | 4007360361235 | 11600041001 | 1951 | https://oxomi.com/p/3000126/datasheet/-/11600041001 | 0.027828
1445005 | Tender Text en | Product URL DE | 12 | 23.7 | 0.00000312848 | REHAU Compression sleeve RAUTITAN PX 16 | 4007360361204 | 11600011001 | 1947 | https://oxomi.com/p/3000126/datasheet/-/11600011001 | 0.0076
1445011 | Tender Text en | Product URL DE | 32 | 37.8 | 0.0000303041 | REHAU Compression sleeve RAUTITAN PX 40 | 4007360361242 | 11600051001 | 1952 | https://oxomi.com/p/3000126/datasheet/-/11600051001 | 0.03861
1445012 | Tender Text en | Product URL DE | 25 | 34 | 0.0000174355 | REHAU Compression sleeve RAUTITAN PX 32 | 4007360361235 | 11600041001 | 1951 | https://oxomi.com/p/3000126/datasheet/-/11600041001 | 0.027828
1445013 | Tender Text en | Product URL DE | 15 | 25 | 0.00000516767 | REHAU Compression sleeve RAUTITAN PX 20 | 4007360361211 | 11600021001 | 1949 | https://oxomi.com/p/3000126/datasheet/-/11600021001 | 0.011
1445021 | Tender Text en | Product URL DE | 15 | 25 | 0.00000516767 | REHAU Compression sleeve RAUTITAN PX 20 | 4007360361211 | 11600021001 | 1949 | https://oxomi.com/p/3000126/datasheet/-/11600021001 | 0.011
1445022 | Tender Text en | Product URL DE | 15 | 25 | 0.00000516767 | REHAU Compression sleeve RAUTITAN PX 20 | 4007360361211 | 11600021001 | 1949 | https://oxomi.com/p/3000126/datasheet/-/11600021001 | 0.011
1445023 | Tender Text en | Product URL DE | 15 | 25 | 0.00000516767 | REHAU Compression sleeve RAUTITAN PX 20 | 4007360361211 | 11600021001 | 1949 | https://oxomi.com/p/3000126/datasheet/-/11600021001 | 0.011
1445029 | Tender Text en | Product URL DE | 15 | 25 | 0.00000516767 | REHAU Compression sleeve RAUTITAN PX 20 | 4007360361211 | 11600021001 | 1949 | https://oxomi.com/p/3000126/datasheet/-/11600021001 | 0.011
1445030 | Tender Text en | Product URL DE | 15 | 25 | 0.00000516767 | REHAU Compression sleeve RAUTITAN PX 20 | 4007360361211 | 11600021001 | 1949 | https://oxomi.com/p/3000126/datasheet/-/11600021001 | 0.011
1445035 | Tender Text en | Product URL DE | 15 | 25 | 0.00000516767 | REHAU Compression sleeve RAUTITAN PX 20 | 4007360361211 | 11600021001 | 1949 | https://oxomi.com/p/3000126/datasheet/-/11600021001 | 0.011
1445039 | Tender Text en | Product URL DE | 15 | 25 | 0.00000516767 | REHAU Compression sleeve RAUTITAN PX 20 | 4007360361211 | 11600021001 | 1949 | https://oxomi.com/p/3000126/datasheet/-/11600021001 | 0.011
1445043 | Tender Text en | Product URL DE | 15 | 25 | 0.00000516767 | REHAU Compression sleeve RAUTITAN PX 20 | 4007360361211 | 11600021001 | 1949 | https://oxomi.com/p/3000126/datasheet/-/11600021001 | 0.011
1445047 | Tender Text en | Product URL DE | 20 | 27.2 | 0.0000087028 | REHAU Compression sleeve RAUTITAN PX 25 | 4007360361228 | 11600031001 | 1950 | https://oxomi.com/p/3000126/datasheet/-/11600031001 | 0.015828
1445051 | Tender Text en | Product URL DE | 20 | 27.2 | 0.0000087028 | REHAU Compression sleeve RAUTITAN PX 25 | 4007360361228 | 11600031001 | 1950 | https://oxomi.com/p/3000126/datasheet/-/11600031001 | 0.015828
1445055 | Tender Text en | Product URL DE | 25 | 34 | 0.0000174355 | REHAU Compression sleeve RAUTITAN PX 32 | 4007360361235 | 11600041001 | 1951 | https://oxomi.com/p/3000126/datasheet/-/11600041001 | 0.027828
1445059 | Tender Text en | Product URL DE | 25 | 34 | 0.0000174355 | REHAU Compression sleeve RAUTITAN PX 32 | 4007360361235 | 11600041001 | 1951 | https://oxomi.com/p/3000126/datasheet/-/11600041001 | 0.027828
1445063 | Tender Text en | Product URL DE | 32 | 37.8 | 0.0000303041 | REHAU Compression sleeve RAUTITAN PX 40 | 4007360361242 | 11600051001 | 1952 | https://oxomi.com/p/3000126/datasheet/-/11600051001 | 0.03861
1445067 | Tender Text en | Product URL DE | 40 | 45 | 0.0000353695 | REHAU Compr. sleeve RAUTITAN PX stabil 50 | 4062178755416 | 11602061001 | 1954 | https://oxomi.com/p/3000126/datasheet/-/11602061001 | 0.0673
1445068 | Tender Text en | Product URL DE | 40 | 45 | 0.0000353695 | REHAU Compr. sleeve RAUTITAN PX stabil 50 | 4062178755416 | 11602061001 | 1954 | https://oxomi.com/p/3000126/datasheet/-/11602061001 | 0.0673
1445079 | Tender Text en | Product URL DE | 50 | 53 | 0.0000702282 | REHAU Compr. sleeve RAUTITAN PX stabil 63 | 4062178755423 | 11602071001 | 1955 | https://oxomi.com/p/3000126/datasheet/-/11602071001 | 0.1106
1445080 | Tender Text en | Product URL DE | 50 | 53 | 0.0000702282 | REHAU Compr. sleeve RAUTITAN PX stabil 63 | 4062178755423 | 11602071001 | 1955 | https://oxomi.com/p/3000126/datasheet/-/11602071001 | 0.1106
1445085 | Tender Text en | Product URL DE | 20 | 27.2 | 0.0000087028 | REHAU Compression sleeve RAUTITAN PX 25 | 4007360361228 | 11600031001 | 1950 | https://oxomi.com/p/3000126/datasheet/-/11600031001 | 0.015828
1445086 | Tender Text en | Product URL DE | 25 | 34 | 0.0000174355 | REHAU Compression sleeve RAUTITAN PX 32 | 4007360361235 | 11600041001 | 1951 | https://oxomi.com/p/3000126/datasheet/-/11600041001 | 0.027828
1445091 | Tender Text en | Product URL DE | 25 | 34 | 0.0000174355 | REHAU Compression sleeve RAUTITAN PX 32 | 4007360361235 | 11600041001 | 1951 | https://oxomi.com/p/3000126/datasheet/-/11600041001 | 0.027828
1445092 | Tender Text en | Product URL DE | 25 | 34 | 0.0000174355 | REHAU Compression sleeve RAUTITAN PX 32 | 4007360361235 | 11600041001 | 1951 | https://oxomi.com/p/3000126/datasheet/-/11600041001 | 0.027828
1445097 | Tender Text en | Product URL DE | 32 | 37.8 | 0.0000303041 | REHAU Compression sleeve RAUTITAN PX 40 | 4007360361242 | 11600051001 | 1952 | https://oxomi.com/p/3000126/datasheet/-/11600051001 | 0.03861
1445098 | Tender Text en | Product URL DE | 32 | 37.8 | 0.0000303041 | REHAU Compression sleeve RAUTITAN PX 40 | 4007360361242 | 11600051001 | 1952 | https://oxomi.com/p/3000126/datasheet/-/11600051001 | 0.03861
1445103 | Tender Text en | Product URL DE | 20 | 27.2 | 0.0000087028 | REHAU Compression sleeve RAUTITAN PX 25 | 4007360361228 | 11600031001 | 1950 | https://oxomi.com/p/3000126/datasheet/-/11600031001 | 0.015828
1445104 | Tender Text en | Product URL DE | 20 | 27.2 | 0.0000087028 | REHAU Compression sleeve RAUTITAN PX 25 | 4007360361228 | 11600031001 | 1950 | https://oxomi.com/p/3000126/datasheet/-/11600031001 | 0.015828
1445109 | Tender Text en | Product URL DE | 25 | 34 | 0.0000174355 | REHAU Compression sleeve RAUTITAN PX 32 | 4007360361235 | 11600041001 | 1951 | https://oxomi.com/p/3000126/datasheet/-/11600041001 | 0.027828
1445110 | Tender Text en | Product URL DE | 25 | 34 | 0.0000174355 | REHAU Compression sleeve RAUTITAN PX 32 | 4007360361235 | 11600041001 | 1951 | https://oxomi.com/p/3000126/datasheet/-/11600041001 | 0.027828
1445115 | Tender Text en | Product URL DE | 15 | 25 | 0.00000516767 | REHAU Compression sleeve RAUTITAN PX 20 | 4007360361211 | 11600021001 | 1949 | https://oxomi.com/p/3000126/datasheet/-/11600021001 | 0.011
1445116 | Tender Text en | Product URL DE | 15 | 25 | 0.00000516767 | REHAU Compression sleeve RAUTITAN PX 20 | 4007360361211 | 11600021001 | 1949 | https://oxomi.com/p/3000126/datasheet/-/11600021001 | 0.011
1445121 | Tender Text en | Product URL DE | 12 | 23.7 | 0.00000312848 | REHAU Compression sleeve RAUTITAN PX 16 | 4007360361204 | 11600011001 | 1947 | https://oxomi.com/p/3000126/datasheet/-/11600011001 | 0.0076
1445122 | Tender Text en | Product URL DE | 12 | 23.7 | 0.00000312848 | REHAU Compression sleeve RAUTITAN PX 16 | 4007360361204 | 11600011001 | 1947 | https://oxomi.com/p/3000126/datasheet/-/11600011001 | 0.0076
1445127 | Tender Text en | Product URL DE | 12 | 23.7 | 0.00000312848 | REHAU Compression sleeve RAUTITAN PX 16 | 4007360361204 | 11600011001 | 1947 | https://oxomi.com/p/3000126/datasheet/-/11600011001 | 0.0076
1445128 | Tender Text en | Product URL DE | 15 | 25 | 0.00000516767 | REHAU Compression sleeve RAUTITAN PX 20 | 4007360361211 | 11600021001 | 1949 | https://oxomi.com/p/3000126/datasheet/-/11600021001 | 0.011
1445133 | Tender Text en | Product URL DE | 15 | 25 | 0.00000516767 | REHAU Compression sleeve RAUTITAN PX 20 | 4007360361211 | 11600021001 | 1949 | https://oxomi.com/p/3000126/datasheet/-/11600021001 | 0.011
1445134 | Tender Text en | Product URL DE | 15 | 25 | 0.00000516767 | REHAU Compression sleeve RAUTITAN PX 20 | 4007360361211 | 11600021001 | 1949 | https://oxomi.com/p/3000126/datasheet/-/11600021001 | 0.011
1447318 | Tender Text en | Product URL DE | 40 | 45 | 0.0000353695 | REHAU Compr. sleeve RAUTITAN PX stabil 50 | 4062178755416 | 11602061001 | 1954 | https://oxomi.com/p/3000126/datasheet/-/11602061001 | 0.0673
1447319 | Tender Text en | Product URL DE | 40 | 45 | 0.0000353695 | REHAU Compr. sleeve RAUTITAN PX stabil 50 | 4062178755416 | 11602061001 | 1954 | https://oxomi.com/p/3000126/datasheet/-/11602061001 | 0.0673
1447324 | Tender Text en | Product URL DE | 50 | 53 | 0.0000702282 | REHAU Compr. sleeve RAUTITAN PX stabil 63 | 4062178755423 | 11602071001 | 1955 | https://oxomi.com/p/3000126/datasheet/-/11602071001 | 0.1106
1447325 | Tender Text en | Product URL DE | 50 | 53 | 0.0000702282 | REHAU Compr. sleeve RAUTITAN PX stabil 63 | 4062178755423 | 11602071001 | 1955 | https://oxomi.com/p/3000126/datasheet/-/11602071001 | 0.1106
1451458 | Tender Text en | Product URL DE | 12 | 23.7 | 0.00000312848 | REHAU Compression sleeve RAUTITAN PX 16 | 4007360361204 | 11600011001 | 1947 | https://oxomi.com/p/3000126/datasheet/-/11600011001 | 0.0076

# IfcPipeSegment: Pipe Types:RAUTITAN Flex LX & RX+ Do (8)
In: REHAU Starting view
Type - Other - Category: Pipes; Family Name: Pipe Types
Type - Identity Data - Assembly Code: 11303701100, 11303801100, 11303901050, 11304001050, 11304101006; Description: Drinking water & heating; Manufacturer: REHAU; Model: RAUTITAN; Type Comments: Do 16-40; Type Name: RAUTITAN Flex LX & RX+ Do; URL: www.rehau.com
Type - Pset_ManufacturerTypeInformation - Manufacturer: REHAU
Classification: 11303701100, 11303801100, 11303901050, 11304001050, 11304101006 (Uniformat)
Pset_EnvironmentalImpactIndicators - Reference: Pipe Types:RAUTITAN Flex LX & RX+ Do; sets with these values: 2
Other - Family: Pipe Types; Family and Type: Pipe Types: RAUTITAN Flex LX & RX+ Do; Type: RAUTITAN Flex LX & RX+ Do; Type Id: 675180
Constraints - End Middle Elevation: 0 mm; Horizontal Justification: Center; Lower End Centerline Elevation: 0 mm; Middle Elevation: 0 mm; Reference Level: REHAU Starting view; Slope: 0; Start Middle Elevation: 0 mm; Upper End Centerline Elevation: 0 mm; Vertical Justification: Middle
Dimensions - Length: 1000 mm
Mechanical - System Type: Domestic Cold Water; Material: RAUTITAN flex; Connection Type: Generic; Pipe Segment: RAUTITAN flex - Do 12 - 63; Roughness: 0.007 mm; Schedule/Type: Do 12 - 63; System Classification: Domestic Cold Water
Mechanical - Flow - Additional Flow: 0 dm3/s; Fixture Units: 0; Flow: 0 dm3/s; Flow State: Laminar; Friction Factor: 0; Pressure Drop: 0 Pa; Reynolds Number: 0; Section: 1; Velocity: 0 m/s; Velocity Pressure: 0 Pa; Friction: 0 kg/m2/s2
Phasing - Phase Created: New Construction
Insulation - Insulation Thickness: 0 mm
Name (Pipe Types:RAUTITAN Flex LX & RX+ Do:...) | InvertElevation (mm) = Lower End Invert Elevation (mm) = Upper End Invert Elevation (mm) = Invert Elevation (mm) | Lower End Bottom Elevation (mm) = Upper End Bottom Elevation (mm) = Lower End Bottom of Insulation Elevation (mm) = Upper End Bottom of Insulation Elevation (mm) | Lower End Obvert Elevation (mm) = Upper End Obvert Elevation (mm) | Lower End Top Elevation (mm) = Upper End Top Elevation (mm) = Lower End Top of Insulation Elevation (mm) = Upper End Top of Insulation Elevation (mm) | Inside Diameter (mm) | Outside Diameter (mm) = Diameter (mm) | Size = Overall Size | Wall Thickness (mm) | Area (m2) | System Name = Group | Relative Roughness
1150842 | -4.3 | -6 | 4.3 | 6 | 8.6 | 12 | 12 mmø | 1.7 | 0.0376991 | Domestic Cold Water 31 | 0.000813953
1150856 | -5.8 | -8 | 5.8 | 8 | 11.6 | 16 | 16 mmø | 2.2 | 0.0502655 | Domestic Cold Water 38 | 0.000603448
1150860 | -7.2 | -10 | 7.2 | 10 | 14.4 | 20 | 20 mmø | 2.8 | 0.0628319 | Domestic Cold Water 40 | 0.000486111
1150862 | -9 | -12.5 | 9 | 12.5 | 18 | 25 | 25 mmø | 3.5 | 0.0785398 | Domestic Cold Water 41 | 0.000388889
1150864 | -11.6 | -16 | 11.6 | 16 | 23.2 | 32 | 32 mmø | 4.4 | 0.100531 | Domestic Cold Water 42 | 0.000301724
1150866 | -14.5 | -20 | 14.5 | 20 | 29 | 40 | 40 mmø | 5.5 | 0.125664 | Domestic Cold Water 43 | 0.000241379
1150868 | -18.1 | -25 | 18.1 | 25 | 36.2 | 50 | 50 mmø | 6.9 | 0.15708 | Domestic Cold Water 44 | 0.00019337
1151436 | -22.9 | -31.5 | 22.9 | 31.5 | 45.8 | 63 | 63 mmø | 8.6 | 0.19792 | Domestic Cold Water 39 | 0.000152838

# IfcPipeSegment: Pipe Types:RAUTITAN Flex PX & RX+ DN (7)
In: REHAU Starting view
Type - Other - Category: Pipes; Family Name: Pipe Types
Type - Identity Data - Assembly Code: 11303701100, 11303801100, 11303901050, 11304001050, 11304101006; Description: Drinking water & heating; Manufacturer: REHAU; Model: RAUTITAN; Type Comments: DN 12-32; Type Name: RAUTITAN Flex PX & RX+ DN; URL: www.rehau.com
Type - Pset_ManufacturerTypeInformation - Manufacturer: REHAU
Classification: 11303701100, 11303801100, 11303901050, 11304001050, 11304101006 (Uniformat)
Pset_EnvironmentalImpactIndicators - Reference: Pipe Types:RAUTITAN Flex PX & RX+ DN; sets with these values: 2
Other - Family: Pipe Types; Family and Type: Pipe Types: RAUTITAN Flex PX & RX+ DN; Type: RAUTITAN Flex PX & RX+ DN; Type Id: 32134
Constraints - End Middle Elevation: 0 mm; Horizontal Justification: Center; Lower End Centerline Elevation: 0 mm; Middle Elevation: 0 mm; Reference Level: REHAU Starting view; Slope: 0; Start Middle Elevation: 0 mm; Upper End Centerline Elevation: 0 mm; Vertical Justification: Middle
Dimensions - Length: 1000 mm
Mechanical - System Type: Domestic Cold Water; Material: RAUTITAN flex; Pipe Segment: RAUTITAN flex - 10 - 50; Schedule/Type: 10 - 50; Connection Type: Generic; Roughness: 0.007 mm; System Classification: Domestic Cold Water
Mechanical - Flow - Additional Flow: 0 dm3/s; Fixture Units: 0; Flow: 0 dm3/s; Flow State: Laminar; Friction Factor: 0; Pressure Drop: 0 Pa; Reynolds Number: 0; Section: 1; Velocity: 0 m/s; Velocity Pressure: 0 Pa; Friction: 0 kg/m2/s2
Phasing - Phase Created: New Construction
Insulation - Insulation Thickness: 0 mm
Name (Pipe Types:RAUTITAN Flex PX & RX+ DN:...) | InvertElevation (mm) = Lower End Invert Elevation (mm) = Upper End Invert Elevation (mm) = Invert Elevation (mm) | Lower End Bottom Elevation (mm) = Upper End Bottom Elevation (mm) = Lower End Bottom of Insulation Elevation (mm) = Upper End Bottom of Insulation Elevation (mm) | Lower End Obvert Elevation (mm) = Upper End Obvert Elevation (mm) | Lower End Top Elevation (mm) = Upper End Top Elevation (mm) = Lower End Top of Insulation Elevation (mm) = Upper End Top of Insulation Elevation (mm) | Inside Diameter (mm) | Outside Diameter (mm) | Size = Overall Size | Wall Thickness (mm) | Area (m2) | Diameter (mm) | System Name = Group | Relative Roughness
1150500 | -5.8 | -8 | 5.8 | 8 | 11.6 | 16 | 12 mmø | 2.2 | 0.0376991 | 12 | Domestic Cold Water 24 | 0.000603448
1150502 | -7.2 | -10 | 7.2 | 10 | 14.4 | 20 | 15 mmø | 2.8 | 0.0471239 | 15 | Domestic Cold Water 25 | 0.000486111
1150504 | -9 | -12.5 | 9 | 12.5 | 18 | 25 | 20 mmø | 3.5 | 0.0628319 | 20 | Domestic Cold Water 26 | 0.000388889
1150506 | -11.6 | -16 | 11.6 | 16 | 23.2 | 32 | 25 mmø | 4.4 | 0.0785398 | 25 | Domestic Cold Water 27 | 0.000301724
1150508 | -14.5 | -20 | 14.5 | 20 | 29 | 40 | 32 mmø | 5.5 | 0.100531 | 32 | Domestic Cold Water 28 | 0.000241379
1150510 | -18.1 | -25 | 18.1 | 25 | 36.2 | 50 | 40 mmø | 6.9 | 0.125664 | 40 | Domestic Cold Water 29 | 0.00019337
1150512 | -22.9 | -31.5 | 22.9 | 31.5 | 45.8 | 63 | 50 mmø | 8.6 | 0.15708 | 50 | Domestic Cold Water 30 | 0.000152838

# IfcPipeSegment: Pipe Types:RAUTITAN Flex PX & RX+ Do (7)
In: REHAU Starting view
Type - Other - Category: Pipes; Family Name: Pipe Types
Type - Identity Data - Assembly Code: 11303701100, 11303801100, 11303901050, 11304001050, 11304101006; Description: Drinking water & heating; Manufacturer: REHAU; Model: RAUTITAN; Type Comments: Do 16-40; Type Name: RAUTITAN Flex PX & RX+ Do; URL: www.rehau.com
Type - Pset_ManufacturerTypeInformation - Manufacturer: REHAU
Classification: 11303701100, 11303801100, 11303901050, 11304001050, 11304101006 (Uniformat)
Pset_EnvironmentalImpactIndicators - Reference: Pipe Types:RAUTITAN Flex PX & RX+ Do; sets with these values: 2
Other - Family: Pipe Types; Family and Type: Pipe Types: RAUTITAN Flex PX & RX+ Do; Type: RAUTITAN Flex PX & RX+ Do; Type Id: 854461
Constraints - End Middle Elevation: 0 mm; Horizontal Justification: Center; Lower End Centerline Elevation: 0 mm; Middle Elevation: 0 mm; Reference Level: REHAU Starting view; Slope: 0; Start Middle Elevation: 0 mm; Upper End Centerline Elevation: 0 mm; Vertical Justification: Middle
Dimensions - Length: 1000 mm
Mechanical - System Type: Domestic Cold Water; Material: RAUTITAN flex; Pipe Segment: RAUTITAN flex - Do 12 - 63; Schedule/Type: Do 12 - 63; Connection Type: Generic; Roughness: 0.007 mm; System Classification: Domestic Cold Water
Mechanical - Flow - Additional Flow: 0 dm3/s; Fixture Units: 0; Flow: 0 dm3/s; Flow State: Laminar; Friction Factor: 0; Pressure Drop: 0 Pa; Reynolds Number: 0; Section: 1; Velocity: 0 m/s; Velocity Pressure: 0 Pa; Friction: 0 kg/m2/s2
Phasing - Phase Created: New Construction
Insulation - Insulation Thickness: 0 mm
Name (Pipe Types:RAUTITAN Flex PX & RX+ Do:...) | InvertElevation (mm) = Lower End Invert Elevation (mm) = Upper End Invert Elevation (mm) = Invert Elevation (mm) | Lower End Bottom Elevation (mm) = Upper End Bottom Elevation (mm) = Lower End Bottom of Insulation Elevation (mm) = Upper End Bottom of Insulation Elevation (mm) | Lower End Obvert Elevation (mm) = Upper End Obvert Elevation (mm) | Lower End Top Elevation (mm) = Upper End Top Elevation (mm) = Lower End Top of Insulation Elevation (mm) = Upper End Top of Insulation Elevation (mm) | Inside Diameter (mm) | Outside Diameter (mm) = Diameter (mm) | Size = Overall Size | Wall Thickness (mm) | Area (m2) | System Name = Group | Relative Roughness
1151469 | -5.8 | -8 | 5.8 | 8 | 11.6 | 16 | 16 mmø | 2.2 | 0.0502655 | Domestic Cold Water 52 | 0.000603448
1151471 | -7.2 | -10 | 7.2 | 10 | 14.4 | 20 | 20 mmø | 2.8 | 0.0628319 | Domestic Cold Water 53 | 0.000486111
1151473 | -9 | -12.5 | 9 | 12.5 | 18 | 25 | 25 mmø | 3.5 | 0.0785398 | Domestic Cold Water 54 | 0.000388889
1151475 | -11.6 | -16 | 11.6 | 16 | 23.2 | 32 | 32 mmø | 4.4 | 0.100531 | Domestic Cold Water 55 | 0.000301724
1151477 | -14.5 | -20 | 14.5 | 20 | 29 | 40 | 40 mmø | 5.5 | 0.125664 | Domestic Cold Water 56 | 0.000241379
1151479 | -18.1 | -25 | 18.1 | 25 | 36.2 | 50 | 50 mmø | 6.9 | 0.15708 | Domestic Cold Water 57 | 0.00019337
1151481 | -22.9 | -31.5 | 22.9 | 31.5 | 45.8 | 63 | 63 mmø | 8.6 | 0.19792 | Domestic Cold Water 58 | 0.000152838

# IfcPipeSegment: Pipe Types:RAUTITAN Stabil LX & RX+ Stabil Do (7)
In: REHAU Starting view
Type - Other - Category: Pipes; Family Name: Pipe Types
Type - Identity Data - Assembly Code: 11300711005, 11301311100, 11301411050, 11301511025, 11301111005, 14601211005, 14601311005; Description: Drinking water & heating; Manufacturer: REHAU; Model: RAUTITAN; Type Comments: Do 16.2-63; Type Name: RAUTITAN Stabil LX & RX+ Stabil Do; URL: www.rehau.com
Type - Pset_ManufacturerTypeInformation - Manufacturer: REHAU
Classification: 11300711005, 11301311100, 11301411050, 11301511025, 11301111005, 14601211005, 14601311005 (Uniformat)
Pset_EnvironmentalImpactIndicators - Reference: Pipe Types:RAUTITAN Stabil LX & RX+ Stabil Do; sets with these values: 2
Other - Family: Pipe Types; Family and Type: Pipe Types: RAUTITAN Stabil LX & RX+ Stabil Do; Type: RAUTITAN Stabil LX & RX+ Stabil Do; Type Id: 859655
Constraints - End Middle Elevation: 0 mm; Horizontal Justification: Center; Lower End Centerline Elevation: 0 mm; Middle Elevation: 0 mm; Reference Level: REHAU Starting view; Slope: 0; Start Middle Elevation: 0 mm; Upper End Centerline Elevation: 0 mm; Vertical Justification: Middle
Dimensions - Length: 1000 mm
Mechanical - Material: RAUTITAN stabil; System Type: Domestic Cold Water; Connection Type: Generic; Pipe Segment: RAUTITAN stabil - Do 16.2 - 63; Roughness: 0.007 mm; Schedule/Type: Do 16.2 - 63; System Classification: Domestic Cold Water
Mechanical - Flow - Additional Flow: 0 dm3/s; Fixture Units: 0; Flow: 0 dm3/s; Flow State: Laminar; Friction Factor: 0; Pressure Drop: 0 Pa; Reynolds Number: 0; Section: 1; Velocity: 0 m/s; Velocity Pressure: 0 Pa; Friction: 0 kg/m2/s2
Phasing - Phase Created: New Construction
Insulation - Insulation Thickness: 0 mm
Name (Pipe Types:RAUTITAN Stabil LX & RX+ Stabil Do:...) | InvertElevation (mm) = Lower End Invert Elevation (mm) = Upper End Invert Elevation (mm) = Invert Elevation (mm) | Lower End Bottom Elevation (mm) = Upper End Bottom Elevation (mm) = Lower End Bottom of Insulation Elevation (mm) = Upper End Bottom of Insulation Elevation (mm) | Lower End Obvert Elevation (mm) = Upper End Obvert Elevation (mm) | Lower End Top Elevation (mm) = Upper End Top Elevation (mm) = Lower End Top of Insulation Elevation (mm) = Upper End Top of Insulation Elevation (mm) | Inside Diameter (mm) | Outside Diameter (mm) | Size = Overall Size | Wall Thickness (mm) | Area (m2) | Diameter (mm) | System Name = Group | Relative Roughness
1150838 | -5.5 | -8.1 | 5.5 | 8.1 | 11 | 16.2 | 16 mmø | 2.6 | 0.0502655 | 16 | Domestic Cold Water 23 | 0.000636364
1150844 | -7.1 | -10 | 7.1 | 10 | 14.2 | 20 | 20 mmø | 2.9 | 0.0628319 | 20 | Domestic Cold Water 32 | 0.000492958
1150846 | -8.8 | -12.5 | 8.8 | 12.5 | 17.6 | 25 | 25 mmø | 3.7 | 0.0785398 | 25 | Domestic Cold Water 33 | 0.000397727
1150848 | -11.3 | -16 | 11.3 | 16 | 22.6 | 32 | 32 mmø | 4.7 | 0.100531 | 32 | Domestic Cold Water 34 | 0.000309735
1150850 | -14 | -20 | 14 | 20 | 28 | 40 | 40 mmø | 6 | 0.125664 | 40 | Domestic Cold Water 35 | 0.00025
1150852 | -20.5 | -25 | 20.5 | 25 | 41 | 50 | 50 mmø | 4.5 | 0.15708 | 50 | Domestic Cold Water 36 | 0.000170732
1151148 | -25.5 | -31.5 | 25.5 | 31.5 | 51 | 63 | 63 mmø | 6 | 0.19792 | 63 | Domestic Cold Water 37 | 0.000137255

# IfcPipeSegment: Pipe Types:RAUTITAN Stabil LX & RX+ stabil DN (7)
In: REHAU Starting view
Type - Other - Category: Pipes; Family Name: Pipe Types
Type - Identity Data - Assembly Code: 11300711005, 11301311100, 11301411050, 11301511025, 11301111005, 14601211005, 14601311005; Description: Drinking water & heating; Manufacturer: REHAU; Model: RAUTITAN; Type Comments: DN 12-50; Type Name: RAUTITAN Stabil LX & RX+ stabil DN; URL: www.rehau.com
Type - Pset_ManufacturerTypeInformation - Manufacturer: REHAU
Classification: 11300711005, 11301311100, 11301411050, 11301511025, 11301111005, 14601211005, 14601311005 (Uniformat)
Pset_EnvironmentalImpactIndicators - Reference: Pipe Types:RAUTITAN Stabil LX & RX+ stabil DN; sets with these values: 2
Other - Family: Pipe Types; Family and Type: Pipe Types: RAUTITAN Stabil LX & RX+ stabil DN; Type: RAUTITAN Stabil LX & RX+ stabil DN; Type Id: 859342
Constraints - End Middle Elevation: 0 mm; Horizontal Justification: Center; Lower End Centerline Elevation: 0 mm; Middle Elevation: 0 mm; Reference Level: REHAU Starting view; Slope: 0; Start Middle Elevation: 0 mm; Upper End Centerline Elevation: 0 mm; Vertical Justification: Middle
Dimensions - Length: 1000 mm
Mechanical - Connection Type: Generic; Material: RAUTITAN stabil; Pipe Segment: RAUTITAN stabil - 12 - 50; Roughness: 0.007 mm; Schedule/Type: 12 - 50; System Classification: Domestic Cold Water; System Type: Domestic Cold Water
Mechanical - Flow - Additional Flow: 0 dm3/s; Fixture Units: 0; Flow: 0 dm3/s; Flow State: Laminar; Friction: 0 kg/m2/s2; Friction Factor: 0; Pressure Drop: 0 Pa; Reynolds Number: 0; Section: 1; Velocity: 0 m/s; Velocity Pressure: 0 Pa
Phasing - Phase Created: New Construction
Insulation - Insulation Thickness: 0 mm
Name (Pipe Types:RAUTITAN Stabil LX & RX+ stabil DN:...) | InvertElevation (mm) = Lower End Invert Elevation (mm) = Upper End Invert Elevation (mm) = Invert Elevation (mm) | Lower End Bottom Elevation (mm) = Upper End Bottom Elevation (mm) = Lower End Bottom of Insulation Elevation (mm) = Upper End Bottom of Insulation Elevation (mm) | Lower End Obvert Elevation (mm) = Upper End Obvert Elevation (mm) | Lower End Top Elevation (mm) = Upper End Top Elevation (mm) = Lower End Top of Insulation Elevation (mm) = Upper End Top of Insulation Elevation (mm) | Inside Diameter (mm) | Outside Diameter (mm) | Size = Overall Size | Wall Thickness (mm) | Area (m2) | Diameter (mm) | System Name = Group | Relative Roughness
1149273 | -5.5 | -8.1 | 5.5 | 8.1 | 11 | 16.2 | 12 mmø | 2.6 | 0.0376991 | 12 | Domestic Cold Water 1 | 0.000636364
1149556 | -7.1 | -10 | 7.1 | 10 | 14.2 | 20 | 15 mmø | 2.9 | 0.0471239 | 15 | Domestic Cold Water 3 | 0.000492958
1149576 | -8.8 | -12.5 | 8.8 | 12.5 | 17.6 | 25 | 20 mmø | 3.7 | 0.0628319 | 20 | Domestic Cold Water 4 | 0.000397727
1149581 | -14 | -20 | 14 | 20 | 28 | 40 | 32 mmø | 6 | 0.100531 | 32 | Domestic Cold Water 5 | 0.00025
1149586 | -20.5 | -25 | 20.5 | 25 | 41 | 50 | 40 mmø | 4.5 | 0.125664 | 40 | Domestic Cold Water 6 | 0.000170732
1149591 | -25.5 | -31.5 | 25.5 | 31.5 | 51 | 63 | 50 mmø | 6 | 0.15708 | 50 | Domestic Cold Water 7 | 0.000137255
1149905 | -11.3 | -16 | 11.3 | 16 | 22.6 | 32 | 25 mmø | 4.7 | 0.0785398 | 25 | Domestic Cold Water 8 | 0.000309735

# IfcPipeSegment: Pipe Types:RAUTITAN Stabil PX & RX+ Stabil DN (7)
In: REHAU Starting view
Type - Other - Category: Pipes; Family Name: Pipe Types
Type - Identity Data - Assembly Code: 11300711005, 11301311100, 11301411050, 11301511025, 11301111005, 14601211005, 14601311005; Description: Drinking water & heating; Manufacturer: REHAU; Model: RAUTITAN; Type Comments: DN 12-50; Type Name: RAUTITAN Stabil PX & RX+ Stabil DN; URL: www.rehau.com
Type - Pset_ManufacturerTypeInformation - Manufacturer: REHAU
Classification: 11300711005, 11301311100, 11301411050, 11301511025, 11301111005, 14601211005, 14601311005 (Uniformat)
Pset_EnvironmentalImpactIndicators - Reference: Pipe Types:RAUTITAN Stabil PX & RX+ Stabil DN; sets with these values: 2
Other - Family: Pipe Types; Family and Type: Pipe Types: RAUTITAN Stabil PX & RX+ Stabil DN; Type: RAUTITAN Stabil PX & RX+ Stabil DN; Type Id: 32136
Constraints - End Middle Elevation: 0 mm; Horizontal Justification: Center; Lower End Centerline Elevation: 0 mm; Middle Elevation: 0 mm; Reference Level: REHAU Starting view; Slope: 0; Start Middle Elevation: 0 mm; Upper End Centerline Elevation: 0 mm; Vertical Justification: Middle
Dimensions - Length: 1000 mm
Mechanical - Material: RAUTITAN stabil; Pipe Segment: RAUTITAN stabil - 12 - 50; Schedule/Type: 12 - 50; System Type: Domestic Cold Water; Connection Type: Generic; Roughness: 0.007 mm; System Classification: Domestic Cold Water
Mechanical - Flow - Additional Flow: 0 dm3/s; Fixture Units: 0; Flow: 0 dm3/s; Flow State: Laminar; Friction Factor: 0; Pressure Drop: 0 Pa; Reynolds Number: 0; Section: 1; Velocity: 0 m/s; Velocity Pressure: 0 Pa; Friction: 0 kg/m2/s2
Phasing - Phase Created: New Construction
Insulation - Insulation Thickness: 0 mm
Name (Pipe Types:RAUTITAN Stabil PX & RX+ Stabil DN:...) | InvertElevation (mm) = Lower End Invert Elevation (mm) = Upper End Invert Elevation (mm) = Invert Elevation (mm) | Lower End Bottom Elevation (mm) = Upper End Bottom Elevation (mm) = Lower End Bottom of Insulation Elevation (mm) = Upper End Bottom of Insulation Elevation (mm) | Lower End Obvert Elevation (mm) = Upper End Obvert Elevation (mm) | Lower End Top Elevation (mm) = Upper End Top Elevation (mm) = Lower End Top of Insulation Elevation (mm) = Upper End Top of Insulation Elevation (mm) | Inside Diameter (mm) | Outside Diameter (mm) | Size = Overall Size | Wall Thickness (mm) | Area (m2) | Diameter (mm) | System Name = Group | Relative Roughness
1150371 | -5.5 | -8.1 | 5.5 | 8.1 | 11 | 16.2 | 12 mmø | 2.6 | 0.0376991 | 12 | Domestic Cold Water 16 | 0.000636364
1150374 | -7.1 | -10 | 7.1 | 10 | 14.2 | 20 | 15 mmø | 2.9 | 0.0471239 | 15 | Domestic Cold Water 17 | 0.000492958
1150376 | -8.8 | -12.5 | 8.8 | 12.5 | 17.6 | 25 | 20 mmø | 3.7 | 0.0628319 | 20 | Domestic Cold Water 18 | 0.000397727
1150378 | -14 | -20 | 14 | 20 | 28 | 40 | 32 mmø | 6 | 0.100531 | 32 | Domestic Cold Water 19 | 0.00025
1150380 | -20.5 | -25 | 20.5 | 25 | 41 | 50 | 40 mmø | 4.5 | 0.125664 | 40 | Domestic Cold Water 20 | 0.000170732
1150382 | -25.5 | -31.5 | 25.5 | 31.5 | 51 | 63 | 50 mmø | 6 | 0.15708 | 50 | Domestic Cold Water 21 | 0.000137255
1150384 | -11.3 | -16 | 11.3 | 16 | 22.6 | 32 | 25 mmø | 4.7 | 0.0785398 | 25 | Domestic Cold Water 22 | 0.000309735

# IfcPipeSegment: Pipe Types:RAUTITAN Stabil PX & RX+ Stabil Do (7)
In: REHAU Starting view
Type - Other - Category: Pipes; Family Name: Pipe Types
Type - Identity Data - Assembly Code: 11300711005, 11301311100, 11301411050, 11301511025, 11301111005, 14601211005, 14601311005; Description: Drinking water & heating; Manufacturer: REHAU; Model: RAUTITAN; Type Comments: Do 16.2-63; Type Name: RAUTITAN Stabil PX & RX+ Stabil Do; URL: www.rehau.com
Type - Pset_ManufacturerTypeInformation - Manufacturer: REHAU
Classification: 11300711005, 11301311100, 11301411050, 11301511025, 11301111005, 14601211005, 14601311005 (Uniformat)
Pset_EnvironmentalImpactIndicators - Reference: Pipe Types:RAUTITAN Stabil PX & RX+ Stabil Do; sets with these values: 2
Other - Family: Pipe Types; Family and Type: Pipe Types: RAUTITAN Stabil PX & RX+ Stabil Do; Type: RAUTITAN Stabil PX & RX+ Stabil Do; Type Id: 680462
Constraints - End Middle Elevation: 0 mm; Horizontal Justification: Center; Lower End Centerline Elevation: 0 mm; Middle Elevation: 0 mm; Reference Level: REHAU Starting view; Slope: 0; Start Middle Elevation: 0 mm; Upper End Centerline Elevation: 0 mm; Vertical Justification: Middle
Dimensions - Length: 1000 mm
Mechanical - Material: RAUTITAN stabil; System Type: Domestic Cold Water; Pipe Segment: RAUTITAN stabil - Do 16.2 - 63; Schedule/Type: Do 16.2 - 63; Connection Type: Generic; Roughness: 0.007 mm; System Classification: Domestic Cold Water
Mechanical - Flow - Additional Flow: 0 dm3/s; Fixture Units: 0; Flow: 0 dm3/s; Flow State: Laminar; Friction Factor: 0; Pressure Drop: 0 Pa; Reynolds Number: 0; Section: 1; Velocity: 0 m/s; Velocity Pressure: 0 Pa; Friction: 0 kg/m2/s2
Phasing - Phase Created: New Construction
Insulation - Insulation Thickness: 0 mm
Name (Pipe Types:RAUTITAN Stabil PX & RX+ Stabil Do:...) | InvertElevation (mm) = Lower End Invert Elevation (mm) = Upper End Invert Elevation (mm) = Invert Elevation (mm) | Lower End Bottom Elevation (mm) = Upper End Bottom Elevation (mm) = Lower End Bottom of Insulation Elevation (mm) = Upper End Bottom of Insulation Elevation (mm) | Lower End Obvert Elevation (mm) = Upper End Obvert Elevation (mm) | Lower End Top Elevation (mm) = Upper End Top Elevation (mm) = Lower End Top of Insulation Elevation (mm) = Upper End Top of Insulation Elevation (mm) | Inside Diameter (mm) | Outside Diameter (mm) | Size = Overall Size | Wall Thickness (mm) | Area (m2) | Diameter (mm) | System Name = Group | Relative Roughness
1151185 | -5.5 | -8.1 | 5.5 | 8.1 | 11 | 16.2 | 16 mmø | 2.6 | 0.0502655 | 16 | Domestic Cold Water 45 | 0.000636364
1151187 | -7.1 | -10 | 7.1 | 10 | 14.2 | 20 | 20 mmø | 2.9 | 0.0628319 | 20 | Domestic Cold Water 46 | 0.000492958
